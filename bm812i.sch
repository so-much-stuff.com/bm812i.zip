# EAGLE board bm812i (EAGLE 4.11), part 5 of 5
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
VCC  (via drill 0.61) (continued)
  Top 0.635: D02.A2 255.56,73.65 255.56,78.22 247.94,78.22 243.37,73.65 D03.A2 242.35,72.63 242.35,71.62 235.24,71.62 234.73,72.12 234.73,72.63 230.67,72.63 D04.A2 230.16,73.65 225.59,78.22 225.59,140.7 227.62,142.74 229.65,142.74 C04.A2 | D08.A2 176.82,72.63 180.88,72.63 180.88,72.12 181.39,71.62 188.5,71.62 188.5,72.63 D07.A2 189.01,73.65 189.01,78.22 196.63,78.22 201.2,73.65 D06.A2 201.71,73.65 201.71,78.22 209.33,78.22 213.9,73.65 D05.A2 | D12.A2 122.97,72.63 122.97,71.62 129.58,71.62 130.08,72.12 130.08,72.63 134.66,72.63 D11.A2 135.16,73.65 135.16,75.17 145.83,75.17 147.36,73.65 D10.A2 147.86,73.65 147.86,76.7 157.01,76.7 160.06,73.65 D09.A2 | v105.19,75.68 106.21,74.66 106.21,73.65 D13.A2 | 201.2,147.31 193.58,147.31 189.52,143.24 C07.A2 188.5,143.24 188.5,147.31 180.88,147.31 176.82,143.24 C08.A2 | 201.2,147.31 201.2,143.24 C06.A2 | 209.84,147.31 213.9,143.24 C05.A2 214.92,143.24 214.92,144.26 v222.03,144.26 | 209.84,147.31 201.2,147.31 | v134.66,145.28 134.66,143.24 C11.A2 | v147.36,145.28 147.36,143.24 C10.A2 | v105.7,145.28 105.7,143.24 C13.A2 | v158.02,145.28 160.06,143.24 C09.A2 | A04.A2 230.67,276.85 235.24,281.42 242.86,281.42 242.86,276.85 A03.A2 | A08.A2 176.82,276.34 180.88,280.4 188.5,280.4 188.5,276.85 A07.A2 | A05.A2 213.9,276.85 209.33,281.42 201.71,281.42 201.71,276.85 A06.A2 | 123.99,277.36 127.04,280.4 134.66,280.4 134.66,276.85 A11.A2 | 123.99,277.36 122.97,276.34 A12.A2 | A09.A2 160.06,275.83 155.48,275.83 155.48,275.32 154.98,274.82 148.37,274.82 148.37,275.83 A10.A2 | 134.66,206.74 130.08,206.74 130.08,207.25 129.58,207.76 122.97,207.76 122.97,206.74 B12.A2
  Top 0.635: 139.74,209.79 134.66,209.79 134.66,206.74 | 139.74,209.79 144.31,209.79 147.36,206.74 B10.A2 148.37,206.74 152.44,206.74 152.44,207.25 153.45,208.27 159.55,208.27 159.55,207.25 160.06,206.74 B09.A2 | 134.66,206.74 B11.A2 | B08.A2 176.82,206.74 180.88,206.74 180.88,207.25 181.39,207.76 188.5,207.76 188.5,206.74 B07.A2 | v104.68,208.78 106.21,207.25 106.21,206.74 B13.A2 | 123.99,277.36 127.04,274.31 127.04,268.72 139.74,256.02 139.74,209.79 | 209.84,147.31 218.98,156.45 218.98,193.03 212.89,199.12 212.89,204.71 213.9,205.73 B05.A2
  Bottom 0.635: D18.A2 40.17,73.65 41.18,74.66 50.33,74.66 51.85,73.14 D17.A2 52.87,73.65 53.38,74.16 57.44,74.16 57.95,74.66 69.63,74.66 | 69.63,74.66 68.62,73.65 D16.A2 | 78.78,74.66 69.63,74.66 | 78.78,74.66 80.3,73.14 D15.A2 | 78.78,74.66 91.48,74.66 93,73.14 D14.A2 94.02,73.65 96.05,75.68 v105.19,75.68 | D02.A2 256.07,73.65 257.08,74.66 266.23,74.66 267.75,73.14 D01.A2 | D13.A2 106.72,72.63 110.78,72.63 111.8,71.62 117.38,71.62 118.4,72.63 121.96,72.63 D12.A2 | D08.A2 175.8,72.63 175.3,72.12 168.18,72.12 167.68,71.62 162.6,71.62 161.58,72.63 161.07,72.63 D09.A2 | D04.A2 229.65,72.63 229.14,72.12 222.54,72.12 222.03,71.62 216.44,71.62 215.43,72.63 214.92,72.63 D05.A2 | 241.34,144.26 231.68,144.26 230.67,143.24 C04.A2 229.65,143.24 228.64,144.26 v222.03,144.26 | 241.34,144.26 242.35,143.24 C03.A2 | 254.04,144.26 255.05,143.24 C02.A2 | 241.34,144.26 254.04,144.26 | 254.04,144.26 266.74,144.26 267.75,143.24 C01.A2 | C09.A2 161.07,142.74 162.09,141.72 165.64,141.72 166.15,141.21 170.22,141.21 171.23,142.23 175.8,142.23 C08.A2 | C13.A2 106.72,142.23 110.78,142.23 111.8,141.21 117.38,141.21 118.4,142.23 121.96,142.23 C12.A2 | 25.44,144.26 15.78,144.26 14.77,143.24 C20.A2 | 25.44,144.26 26.45,143.24 C19.A2 | 38.14,144.26 39.15,143.24 C18.A2 | 38.14,144.26 25.44,144.26 | 50.84,144.26 51.85,143.24 C17.A2 | 50.84,144.26 38.14,144.26 | 66.58,144.26 67.6,143.24 C16.A2 | 66.58,144.26 50.84,144.26 | 79.28,144.26 80.3,143.24 C15.A2 | 79.28,144.26 66.58,144.26 | 79.28,144.26 91.98,144.26 93,143.24 C14.A2 94.02,143.24 96.05,145.28 v105.7,145.28 v134.66,145.28 v147.36,145.28 v158.02,145.28
  Bottom 0.635: +5V.1 279.94,281.93 273.85,281.93 268.77,276.85 A01.A2 267.75,276.34 266.23,277.86 253.53,277.86 | 253.53,277.86 255.05,276.34 A02.A2 | 253.53,277.86 244.38,277.86 243.37,276.85 A03.A2 | A06.A2 201.2,276.85 200.19,277.86 191.04,277.86 189.52,276.34 A07.A2 | A15.A2 81.32,275.83 82.33,274.82 88.94,274.82 89.95,275.83 93,275.83 A14.A2 94.02,275.83 98.08,275.83 99.1,274.82 101.13,274.82 101.64,275.32 105.19,275.32 105.7,275.83 A13.A2 106.72,275.83 107.22,275.32 111.29,275.32 111.8,274.82 117.38,274.82 118.4,275.83 121.96,275.83 A12.A2 | A10.A2 147.36,276.85 146.34,277.86 137.2,277.86 135.67,276.34 A11.A2 | A08.A2 175.8,275.83 175.3,275.32 168.18,275.32 167.68,274.82 162.6,274.82 161.58,275.83 161.07,275.83 A09.A2 | A04.A2 229.65,275.83 229.14,275.32 222.54,275.32 222.03,274.82 216.44,274.82 215.43,275.83 214.92,275.83 A05.A2 | 24.93,207.76 15.78,207.76 14.77,206.74 B20.A2 | 24.93,207.76 25.94,206.74 B19.A2 | 37.63,207.76 38.64,206.74 B18.A2 | 37.63,207.76 24.93,207.76 | 50.33,207.76 51.34,206.74 B17.A2 | 50.33,207.76 37.63,207.76 | 66.58,207.76 67.6,206.74 B16.A2 | 50.33,207.76 66.58,207.76 | 79.28,207.76 80.3,206.74 B15.A2 | 66.58,207.76 79.28,207.76 | 79.28,207.76 91.98,207.76 93,206.74 B14.A2 94.02,206.74 95.03,207.76 100.62,207.76 101.13,208.27 104.18,208.27 v104.68,208.78 | B13.A2 106.72,205.73 107.73,204.71 114.34,204.71 115.35,205.73 121.96,205.73 B12.A2 | B09.A2 161.07,206.24 162.6,204.71 167.68,204.71 168.69,205.73 175.8,205.73 B08.A2 | 200.19,207.76 190.54,207.76 189.52,206.74 B07.A2 | 200.19,207.76 201.2,206.74 B06.A2 | 212.89,207.76 213.9,206.74 B05.A2
  Bottom 0.635: 200.19,207.76 212.89,207.76 | 228.64,207.76 229.65,206.74 B04.A2 | 212.89,207.76 228.64,207.76 | 241.34,207.76 242.35,206.74 B03.A2 | 228.64,207.76 241.34,207.76 | 254.04,207.76 255.05,206.74 B02.A2 | 241.34,207.76 254.04,207.76 | 254.04,207.76 266.74,207.76 267.75,206.74 B01.A2

## Text on the board
Top: 1 | A
Bottom: VRS | A | VRS
tPlace: 20 | 19 | 18 | 17 | 16 | 15 | 14 | 13 | 12 | 11 | 10 | 9 | 8 | 7 | 6 | 5 | 4 | 3 | 2 | 1 | Fold in ECOs. | A | B | C | D
bPlace: A | B | C | D | 11 | 20 | 19 | 18 | 17 | 16 | 15 | 14 | 13 | 12 | 10 | 9 | 8 | 7 | 6 | 5 | 4 | 3 | 2 | 1