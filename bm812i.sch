# EAGLE board bm812i (EAGLE 4.11), part 4 of 5
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
N$126  (via drill 0.61) (continued)
  Bottom 0.254: B09.R2 154.47,165.09 152.94,163.56 145.83,163.56 144.82,164.58 B10.R2 143.8,165.09 142.78,164.07 139.23,164.07 138.72,163.56 134.66,163.56 133.64,164.58 132.12,164.58 B11.R2 129.07,165.09 127.54,163.56 120.43,163.56 119.42,164.58 B12.R2 | B13.R2 102.65,165.6 99.6,165.6 98.59,166.61 96.05,166.61 95.54,166.1 91.48,166.1 90.97,165.6 B14.R2 90.97,164.58 90.97,160.01 v129.07,160.01 v182.92,160.01 | 250.99,166.61 245.4,166.61 244.89,166.1 240.83,166.1 240.32,165.6 B03.R2 239.3,165.6 238.8,166.1 234.73,166.1 234.22,166.61 231.68,166.61 230.67,165.6 227.62,165.6 B04.R2 226.6,165.6 225.59,166.61 216.95,166.61 215.43,165.09 B05.R2 210.86,165.6 209.84,166.61 200.7,166.61 | 250.99,166.61 252,165.6 B02.R2 | 250.99,166.61 263.69,166.61 264.7,165.6 B01.R2 | B08.R2 173.77,165.09 175.3,166.61 182.92,166.61 183.93,165.6 185.46,165.6 B07.R2 186.47,165.09 187.49,166.1 191.04,166.1 191.55,166.61 200.7,166.61 | 200.7,166.61 199.17,165.09 B06.R2
N$127
  Bottom 0.254: 111.29,160.52 101.64,160.52 100.62,161.53 B14.S1 | 111.29,160.52 112.3,161.53 B13.S1 | 111.29,160.52 127.04,160.52 128.05,161.53 B12.S1 129.07,161.53 130.08,160.52 139.74,160.52 | 139.74,160.52 140.75,161.53 B11.S1 | 152.44,160.52 153.45,161.53 B10.S1 | 139.74,160.52 152.44,160.52 | 165.14,160.52 166.15,161.53 B09.S1 | 152.44,160.52 165.14,160.52 | 165.14,160.52 180.88,160.52 181.9,161.53 B08.S1 182.92,161.53 183.93,160.52 193.58,160.52 | 193.58,160.52 194.6,161.53 B07.S1 | 206.28,160.52 207.3,161.53 B06.S1 | 193.58,160.52 206.28,160.52 | 218.98,160.52 220,161.53 B05.S1 | 206.28,160.52 218.98,160.52 | 235.24,160.52 236.26,161.53 B04.S1 | 218.98,160.52 235.24,160.52 | 247.94,160.52 248.96,161.53 B03.S1 | 235.24,160.52 247.94,160.52 | 260.64,160.52 261.66,161.53 B02.S1 | 247.94,160.52 260.64,160.52 | 260.64,160.52 273.34,160.52 274.36,161.53 B01.S1
N$128  (via drill 0.61)
  Top 0.254: v18.32,58.92 18.83,59.42 v18.83,73.65 | v58.96,75.68 57.44,74.16 57.44,72.12 57.95,71.62 60.49,71.62 60.49,117.84 61,118.35 v61,146.8 | v77.25,154.93 76.74,155.44 76.74,157.47 76.24,157.98 76.24,159.5 76.74,160.01 76.74,164.07 76.24,164.58 76.24,166.1 76.74,166.61 76.74,170.17 76.24,170.68 76.24,183.38 71.66,187.95 71.66,189.98 B16.F1
  Bottom 0.254: v18.32,58.92 21.88,58.92 23.4,57.39 D19.F2 | v18.83,73.65 32.04,86.86 56.42,86.86 59.98,83.3 59.98,75.68 v58.96,75.68 | v61,146.8 63.54,149.34 71.66,149.34 v77.25,154.93
N$129  (via drill 0.61)
  Top 0.254: v46.77,11.16 25.44,32.5 25.44,49.26 24.42,50.28 D19.J2 | v132.62,11.16 159.04,37.58 159.04,69.58 161.58,72.12 161.58,74.16 160.06,75.68 159.04,75.68 148.88,85.84 v148.88,191 | v111.8,192.01 107.73,196.08 107.73,203.19 v106.21,204.71 | v94.52,204.71 88.94,199.12 88.94,193.03 v87.92,192.01
  Bottom 0.254: v132.62,11.16 v46.77,11.16 | v148.88,191 147.86,192.01 142.78,192.01 142.28,191.5 139.23,191.5 138.72,192.01 131.1,192.01 130.59,191.5 126.53,191.5 126.02,192.01 v111.8,192.01 | v106.21,204.71 104.68,204.71 104.18,205.22 100.62,205.22 100.11,204.71 v94.52,204.71 | v87.92,192.01 76.74,192.01 75.22,193.54 B16.E1
N$130
  Bottom 0.254: B01.S2 267.75,162.04 266.74,163.06 263.18,163.06 262.67,163.56 257.08,163.56 256.07,162.55 B02.S2 255.05,162.04 252.51,162.04 250.99,163.56 244.38,163.56 243.37,162.55 B03.S2 242.35,162.04 241.34,163.06 237.78,163.06 237.27,163.56 231.68,163.56 230.67,162.55 B04.S2 229.65,162.04 226.6,162.04 225.08,163.56 216.44,163.56 214.92,162.04 B05.S2 213.9,162.55 210.35,162.55 209.33,163.56 203.74,163.56 202.22,162.04 B06.S2 201.2,162.55 197.65,162.55 196.63,163.56 191.04,163.56 189.52,162.04 B07.S2 188.5,162.55 188,163.06 183.93,163.06 183.42,163.56 178.85,163.56 177.33,162.04 176.82,162.04 B08.S2 175.8,162.55 175.3,163.06 167.68,163.06 167.17,163.56 159.04,163.56 | 159.04,163.56 153.96,163.56 153.45,163.06 149.39,163.06 148.37,162.04 B10.S2 147.36,162.55 146.85,163.06 142.28,163.06 141.77,163.56 139.74,163.56 138.21,162.04 135.67,162.04 B11.S2 134.66,162.55 133.64,163.56 128.56,163.56 128.05,163.06 123.99,163.06 122.97,162.04 B12.S2 121.96,162.55 120.43,162.55 119.42,163.56 107.73,163.56 106.72,162.55 B13.S2 105.7,162.04 103.16,162.04 101.64,163.56 95.03,163.56 94.02,162.55 B14.S2 | 159.04,163.56 160.06,162.55 B09.S2
N$132  (via drill 0.61)
  Top 0.254: v54.9,155.44 59.98,160.52 59.98,177.28 v56.42,180.84
  Bottom 0.254: v54.9,155.44 52.87,155.44 B17.U2 | v56.42,180.84 57.95,182.36 66.58,182.36 67.6,183.38 71.16,183.38 B16.J1
N$134  (via drill 0.61)
  Top 0.254: v113.32,157.98 113.32,155.94 B13.U1 | B07.U1 195.62,155.94 200.19,155.94 200.19,156.45 200.7,156.96 207.3,156.96 207.3,155.94 B06.U1 | B03.U1 249.97,155.94 254.04,155.94 255.05,156.96 261.66,156.96 261.66,155.94 B02.U1 | v175.3,156.96 181.9,156.96 181.9,155.94 B08.U1
  Bottom 0.254: B14.U1 100.62,155.44 102.14,153.91 107.73,153.91 109.26,155.44 112.3,155.44 B13.U1 | 139.74,156.96 130.08,156.96 129.07,155.94 B12.U1 128.05,155.94 126.53,157.47 113.83,157.47 v113.32,157.98 | 139.74,156.96 140.75,155.94 B11.U1 | 152.44,156.96 153.45,155.94 B10.U1 | 139.74,156.96 152.44,156.96 | 152.44,156.96 165.14,156.96 166.15,155.94 B09.U1 167.17,155.94 168.18,156.96 v175.3,156.96 | B08.U1 182.92,154.93 183.93,153.91 190.54,153.91 192.06,155.44 194.6,155.44 B07.U1 | B06.U1 208.32,154.93 208.82,154.42 213.4,154.42 213.9,153.91 214.92,153.91 216.44,155.44 220,155.44 B05.U1 221.02,154.93 222.03,153.91 233.72,153.91 234.73,154.93 236.26,154.93 B04.U1 237.27,155.44 238.29,154.42 242.35,154.42 242.86,153.91 247.94,153.91 248.96,154.93 B03.U1 | B02.U1 262.67,155.44 263.69,154.42 267.75,154.42 268.26,153.91 273.34,153.91 274.36,154.93 B01.U1
N$135
  Bottom 0.254: B14.U2 94.02,155.94 95.03,156.96 104.68,156.96 105.7,155.94 B13.U2 106.72,155.94 109.26,155.94 110.27,156.96 120.94,156.96 121.96,155.94 B12.U2 122.97,155.44 123.48,155.44 125,153.91 129.07,153.91 129.58,154.42 134.15,154.42 134.66,154.93 B11.U2 135.67,155.44 136.69,154.42 140.75,154.42 141.26,153.91 141.77,153.91 142.78,154.93 147.36,154.93 B10.U2 148.37,155.44 149.9,153.91 155.48,153.91 156.5,154.93 160.06,154.93 B09.U2 161.07,155.44 162.6,153.91 171.23,153.91 172.25,154.93 175.8,154.93 B08.U2 176.82,155.94 177.33,156.45 181.39,156.45 181.9,156.96 187.49,156.96 | 187.49,156.96 188.5,155.94 B07.U2 | 200.19,156.96 201.2,155.94 B06.U2 | 187.49,156.96 200.19,156.96 | 212.89,156.96 213.9,155.94 B05.U2 | 200.19,156.96 212.89,156.96 | 228.64,156.96 229.65,155.94 B04.U2 | 212.89,156.96 228.64,156.96 | 241.34,156.96 242.35,155.94 B03.U2 | 228.64,156.96 241.34,156.96 | 254.04,156.96 255.05,155.94 B02.U2 | 241.34,156.96 254.04,156.96 | 254.04,156.96 266.74,156.96 267.75,155.94 B01.U2
N$136  (via drill 0.61)
  Top 0.254: v108.75,149.85 109.26,150.36 109.26,151.88 B13.V1 | B03.V1 246.42,151.88 250.99,151.88 252,150.86 258.1,150.86 258.1,152.39 B02.V1 | v177.33,153.91 178.85,152.39 B08.V1
  Bottom 0.254: v108.75,149.85 108.24,150.36 99.6,150.36 97.57,152.39 B14.V1 | B13.V1 112.3,152.39 113.83,153.91 123.99,153.91 125,152.9 B12.V1 126.02,152.9 130.08,152.9 131.1,153.91 136.69,153.91 137.7,152.9 B11.V1 138.72,152.9 141.77,152.9 142.78,153.91 145.32,153.91 145.83,153.4 149.9,153.4 150.4,152.9 B10.V1 151.42,152.9 151.93,153.4 155.99,153.4 156.5,153.91 161.58,153.91 162.6,152.9 163.1,152.9 B09.V1 164.12,152.9 164.63,153.4 171.74,153.4 172.25,153.91 v177.33,153.91 | 190.54,150.86 180.88,150.86 179.87,151.88 B08.V1 | 190.54,150.86 191.55,151.88 B07.V1 | 203.24,150.86 204.25,151.88 B06.V1 | 190.54,150.86 203.24,150.86 | 203.24,150.86 215.94,150.86 216.95,151.88 B05.V1 217.97,151.88 219.49,150.36 256.07,150.36 258.1,152.39 B02.V1 259.12,151.88 260.13,150.86 269.28,150.86 270.8,152.39 B01.V1 | B04.V1 233.72,152.9 234.73,153.91 241.84,153.91 243.37,152.39 B03.V1
N$141
  Bottom 0.254: 264.2,141.21 262.67,142.74 C02.A1 | 264.2,141.21 273.34,141.21 274.36,142.23 C01.A1 | 264.2,141.21 251.5,141.21 249.97,142.74 C03.A1 248.96,142.23 244.89,142.23 243.88,141.21 238.8,141.21 237.27,142.74 C04.A1 236.26,142.23 235.24,141.21 228.64,141.21 227.62,142.23 221.02,142.23 C05.A1 220,143.24 218.98,144.26 206.28,144.26 | 111.29,144.26 101.64,144.26 100.62,143.24 C14.A1 | 111.29,144.26 112.3,143.24 C13.A1 | 127.04,144.26 128.05,143.24 C12.A1 | 111.29,144.26 127.04,144.26 | 139.74,144.26 140.75,143.24 C11.A1 | 127.04,144.26 139.74,144.26 | 152.44,144.26 153.45,143.24 C10.A1 | 139.74,144.26 152.44,144.26 | 165.14,144.26 166.15,143.24 C09.A1 | 152.44,144.26 165.14,144.26 | 180.88,144.26 181.9,143.24 C08.A1 | 165.14,144.26 180.88,144.26 | 193.58,144.26 194.6,143.24 C07.A1 | 180.88,144.26 193.58,144.26 | 206.28,144.26 207.3,143.24 C06.A1 | 193.58,144.26 206.28,144.26
N$144
  Bottom 0.254: 243.88,138.16 234.73,138.16 233.72,139.18 C04.B1 232.7,139.69 231.68,140.7 228.13,140.7 227.62,141.21 215.94,141.21 | 243.88,138.16 245.4,139.69 C03.B1 | 256.58,138.16 258.1,139.69 C02.B1 | 243.88,138.16 256.58,138.16 | 256.58,138.16 269.28,138.16 270.8,139.69 C01.B1 | 190.54,141.21 180.88,141.21 179.87,140.2 C08.B1 178.85,140.2 177.84,141.21 171.23,141.21 170.22,140.2 164.12,140.2 C09.B1 163.1,140.2 162.6,140.7 158.53,140.7 158.02,141.21 149.39,141.21 | 190.54,141.21 191.55,140.2 C07.B1 | 203.24,141.21 204.25,140.2 C06.B1 | 190.54,141.21 203.24,141.21 | 215.94,141.21 216.95,140.2 C05.B1 | 203.24,141.21 215.94,141.21 | C14.B1 97.57,139.69 98.59,140.7 102.14,140.7 102.65,141.21 103.67,141.21 104.68,140.2 109.26,140.2 C13.B1 110.27,139.69 110.78,140.2 117.38,140.2 118.4,141.21 127.04,141.21 | 127.04,141.21 126.02,140.2 C12.B1 | 127.04,141.21 136.69,141.21 | 136.69,141.21 137.7,140.2 C11.B1 | 149.39,141.21 150.4,140.2 C10.B1 | 136.69,141.21 149.39,141.21
N$154
  Bottom 0.254: 108.75,132.07 98.59,132.07 97.57,133.08 C14.D1 | 108.75,132.07 109.26,132.58 C13.D1 | 123.99,132.07 125,133.08 C12.D1 | 123.99,132.07 108.75,132.07 | 136.69,132.07 137.7,133.08 C11.D1 | 123.99,132.07 136.69,132.07 | 149.39,132.07 150.4,133.08 C10.D1 | 136.69,132.07 149.39,132.07 | 162.09,132.07 163.1,133.08 C09.D1 | 149.39,132.07 162.09,132.07 | 177.84,132.07 178.85,133.08 C08.D1 | 162.09,132.07 177.84,132.07 | 190.54,132.07 191.55,133.08 C07.D1 | 177.84,132.07 190.54,132.07 | 203.24,132.07 204.25,133.08 C06.D1 | 190.54,132.07 203.24,132.07 | 215.94,132.07 216.95,133.08 C05.D1 | 203.24,132.07 215.94,132.07 | 231.68,132.07 232.7,133.08 C04.D1 | 215.94,132.07 231.68,132.07 | 244.38,132.07 245.4,133.08 C03.D1 | 231.68,132.07 244.38,132.07 | 257.08,132.07 258.1,133.08 C02.D1 | 244.38,132.07 257.08,132.07 | 257.08,132.07 269.78,132.07 270.8,133.08 C01.D1
N$156
  Bottom 0.254: 101.64,134.61 91.98,134.61 90.97,133.59 C14.D2 | 101.64,134.61 102.65,133.59 C13.D2 | 117.38,134.61 118.4,133.59 C12.D2 | 117.38,134.61 101.64,134.61 | 130.08,134.61 131.1,133.59 C11.D2 | 130.08,134.61 117.38,134.61 | 142.78,134.61 143.8,133.59 C10.D2 | 130.08,134.61 142.78,134.61 | 155.48,134.61 156.5,133.59 C09.D2 | 142.78,134.61 155.48,134.61 | 172.25,134.61 172.76,134.1 C08.D2 | 155.48,134.61 172.25,134.61 | 184.95,134.61 185.46,134.1 C07.D2 | 172.25,134.61 184.95,134.61 | 197.65,134.61 198.16,134.1 C06.D2 | 184.95,134.61 197.65,134.61 | 210.35,134.61 210.86,134.1 C05.D2 | 197.65,134.61 210.35,134.61 | 225.59,134.61 226.6,133.59 C04.D2 | 210.35,134.61 225.59,134.61 | 238.29,134.61 239.3,133.59 C03.D2 | 225.59,134.61 238.29,134.61 | 250.99,134.61 252,133.59 C02.D2 | 238.29,134.61 250.99,134.61 | 250.99,134.61 263.69,134.61 264.7,133.59 C01.D2
N$157  (via drill 0.61)
  Top 0.254: v122.97,128.51 128.05,128.51 128.05,130.04 C12.E1 | v168.69,127.5 168.69,128 167.17,129.53 C09.E1
  Bottom 0.254: C14.E1 100.62,130.04 102.14,128.51 111.29,128.51 112.3,129.53 C13.E1 113.32,130.04 114.84,128.51 v122.97,128.51 | 139.74,131.56 130.08,131.56 129.07,130.54 C12.E1 | 139.74,131.56 140.75,130.54 C11.E1 | 152.44,131.56 153.45,130.54 C10.E1 | 139.74,131.56 152.44,131.56 | 152.44,131.56 165.14,131.56 166.15,130.54 C09.E1 | 183.93,128.51 182.92,129.53 C08.E1 | 183.93,128.51 193.08,128.51 | 193.08,128.51 194.6,130.04 C07.E1 | 205.78,128.51 207.3,130.04 C06.E1 | 193.08,128.51 205.78,128.51 | 218.48,128.51 220,130.04 C05.E1 | 205.78,128.51 218.48,128.51 | 235.24,128.51 236.26,129.53 C04.E1 | 218.48,128.51 235.24,128.51 | 247.94,128.51 248.96,129.53 C03.E1 | 235.24,128.51 247.94,128.51 | 260.64,128.51 261.66,129.53 C02.E1 | 247.94,128.51 260.64,128.51 | 260.64,128.51 273.34,128.51 274.36,129.53 C01.E1 | v168.69,127.5 169.2,128 171.74,128 172.25,128.51 183.93,128.51
N$158
  Bottom 0.254: 146.34,128.51 137.2,128.51 135.67,130.04 C11.E2 134.66,129.53 133.64,128.51 124.5,128.51 122.97,130.04 C12.E2 121.96,130.54 120.94,131.56 104.68,131.56 | 146.34,128.51 147.36,129.53 C10.E2 | 146.34,128.51 159.04,128.51 160.06,129.53 C09.E2 161.07,130.04 162.09,129.02 166.15,129.02 166.66,128.51 171.23,128.51 172.25,129.53 175.8,129.53 C08.E2 176.82,130.54 177.84,131.56 187.49,131.56 | 104.68,131.56 95.03,131.56 94.02,130.54 C14.E2 | 104.68,131.56 105.7,130.54 C13.E2 | 187.49,131.56 188.5,130.54 C07.E2 | 200.19,131.56 201.2,130.54 C06.E2 | 187.49,131.56 200.19,131.56 | 212.89,131.56 213.9,130.54 C05.E2 | 200.19,131.56 212.89,131.56 | 228.64,131.56 229.65,130.54 C04.E2 | 212.89,131.56 228.64,131.56 | 241.34,131.56 242.35,130.54 C03.E2 | 228.64,131.56 241.34,131.56 | 254.04,131.56 255.05,130.54 C02.E2 | 241.34,131.56 254.04,131.56 | 254.04,131.56 266.74,131.56 267.75,130.54 C01.E2
N$163  (via drill 0.61)
  Top 0.254: v120.43,123.43 121.45,122.42 128.05,122.42 128.05,123.43 C12.H1
  Bottom 0.254: C14.H1 100.62,123.94 101.64,124.96 105.19,124.96 105.7,125.46 107.73,125.46 108.75,124.45 112.3,124.45 C13.H1 113.32,123.43 v120.43,123.43 | 139.23,125.46 130.08,125.46 129.07,124.45 C12.H1 | 139.23,125.46 140.75,123.94 C11.H1 | 151.93,125.46 153.45,123.94 C10.H1 | 139.23,125.46 151.93,125.46 | 164.63,125.46 166.15,123.94 C09.H1 | 151.93,125.46 164.63,125.46 | 180.38,125.46 181.9,123.94 C08.H1 | 164.63,125.46 180.38,125.46 | 193.08,125.46 194.6,123.94 C07.H1 | 180.38,125.46 193.08,125.46 | 205.78,125.46 207.3,123.94 C06.H1 | 193.08,125.46 205.78,125.46 | 218.48,125.46 220,123.94 C05.H1 | 205.78,125.46 218.48,125.46 | 235.24,125.46 236.26,124.45 C04.H1 | 218.48,125.46 235.24,125.46 | 247.94,125.46 248.96,124.45 C03.H1 | 235.24,125.46 247.94,125.46 | 260.64,125.46 261.66,124.45 C02.H1 | 247.94,125.46 260.64,125.46 | 260.64,125.46 273.34,125.46 274.36,124.45 C01.H1
N$164
  Top 0.254: C14.H2 94.02,123.43 98.59,123.43 98.59,122.92 99.1,122.42 105.7,122.42 105.7,123.43 C13.H2
  Bottom 0.254: 133.64,122.42 123.99,122.42 122.97,123.43 C12.H2 121.96,124.45 120.94,125.46 108.75,125.46 108.24,125.97 105.19,125.97 104.68,125.46 95.03,125.46 94.02,124.45 C14.H2 | 133.64,122.42 134.66,123.43 C11.H2 | 146.34,122.42 147.36,123.43 C10.H2 | 133.64,122.42 146.34,122.42 | 159.04,122.42 160.06,123.43 C09.H2 | 146.34,122.42 159.04,122.42 | 174.79,122.42 175.8,123.43 C08.H2 | 159.04,122.42 174.79,122.42 | 187.49,122.42 188.5,123.43 C07.H2 | 174.79,122.42 187.49,122.42 | 200.19,122.42 201.2,123.43 C06.H2 | 187.49,122.42 200.19,122.42 | 212.89,122.42 213.9,123.43 C05.H2 | 200.19,122.42 212.89,122.42 | 228.64,122.42 229.65,123.43 C04.H2 | 212.89,122.42 228.64,122.42 | 241.34,122.42 242.35,123.43 C03.H2 | 228.64,122.42 241.34,122.42 | 254.04,122.42 255.05,123.43 C02.H2 | 241.34,122.42 254.04,122.42 | 254.04,122.42 266.74,122.42 267.75,123.43 C01.H2
N$165
  Bottom 0.254: 108.75,119.37 98.59,119.37 97.57,120.38 C14.J1 | 108.75,119.37 109.26,119.88 C13.J1 | 123.99,119.37 125,120.38 C12.J1 | 123.99,119.37 108.75,119.37 | 136.69,119.37 137.7,120.38 C11.J1 | 136.69,119.37 123.99,119.37 | 149.39,119.37 150.4,120.38 C10.J1 | 136.69,119.37 149.39,119.37 | 162.09,119.37 163.1,120.38 C09.J1 | 149.39,119.37 162.09,119.37 | 177.84,119.37 178.85,120.38 C08.J1 | 162.09,119.37 177.84,119.37 | 190.54,119.37 191.55,120.38 C07.J1 | 177.84,119.37 190.54,119.37 | 203.24,119.37 204.25,120.38 C06.J1 | 190.54,119.37 203.24,119.37 | 215.94,119.37 216.95,120.38 C05.J1 | 203.24,119.37 215.94,119.37 | 231.68,119.37 232.7,120.38 C04.J1 | 215.94,119.37 231.68,119.37 | 244.38,119.37 245.4,120.38 C03.J1 | 231.68,119.37 244.38,119.37 | 257.08,119.37 258.1,120.38 C02.J1 | 244.38,119.37 257.08,119.37 | 257.08,119.37 269.78,119.37 270.8,120.38 C01.J1
N$166
  Bottom 0.254: 101.64,121.91 91.98,121.91 90.97,120.89 C14.J2 | 101.64,121.91 102.65,120.89 C13.J2 | 101.64,121.91 117.38,121.91 118.4,120.89 C12.J2 119.42,121.4 119.92,121.91 130.08,121.91 | 130.08,121.91 131.1,120.89 C11.J2 | 142.78,121.91 143.8,120.89 C10.J2 | 142.78,121.91 130.08,121.91 | 155.48,121.91 156.5,120.89 C09.J2 | 142.78,121.91 155.48,121.91 | 172.25,121.91 172.76,121.4 C08.J2 | 155.48,121.91 172.25,121.91 | 184.95,121.91 185.46,121.4 C07.J2 | 172.25,121.91 184.95,121.91 | 197.65,121.91 198.16,121.4 C06.J2 | 184.95,121.91 197.65,121.91 | 210.35,121.91 210.86,121.4 C05.J2 | 197.65,121.91 210.35,121.91 | 225.59,121.91 226.6,120.89 C04.J2 | 210.35,121.91 225.59,121.91 | 238.29,121.91 239.3,120.89 C03.J2 | 225.59,121.91 238.29,121.91 | 250.99,121.91 252,120.89 C02.J2 | 238.29,121.91 250.99,121.91 | 250.99,121.91 263.69,121.91 264.7,120.89 C01.J2
N$167  (via drill 0.61)
  Top 0.254: v120.43,117.84 121.45,118.86 128.05,118.86 128.05,117.84 C12.K1 | C07.K1 195.62,117.84 200.19,117.84 200.19,118.35 200.7,118.86 207.3,118.86 207.3,117.84 C06.K1 | C01.K1 274.36,117.84 274.36,118.86 267.75,118.86 266.74,117.84 262.67,117.84 C02.K1 261.66,117.84 261.66,118.86 255.05,118.86 254.04,117.84 249.97,117.84 C03.K1 | v168.69,115.3 167.17,116.83 C09.K1
  Bottom 0.254: C14.K1 100.62,117.34 102.14,115.81 110.78,115.81 111.8,116.83 112.3,116.83 C13.K1 113.32,117.84 v120.43,117.84 | 139.74,118.86 130.08,118.86 129.07,117.84 C12.K1 | 139.74,118.86 140.75,117.84 C11.K1 | 152.44,118.86 153.45,117.84 C10.K1 | 139.74,118.86 152.44,118.86 | 152.44,118.86 165.14,118.86 166.15,117.84 C09.K1 | C07.K1 194.6,117.34 192.06,117.34 190.54,115.81 183.93,115.81 182.92,116.83 C08.K1 181.9,117.34 179.36,117.34 177.84,115.81 169.2,115.81 v168.69,115.3 | C06.K1 208.32,116.83 208.82,116.32 213.4,116.32 213.9,115.81 215.94,115.81 217.46,117.34 220,117.34 C05.K1 221.02,116.83 222.03,115.81 233.72,115.81 234.73,116.83 236.26,116.83 C04.K1 237.27,117.34 238.29,116.32 242.35,116.32 242.86,115.81 246.42,115.81 247.43,116.83 248.96,116.83 C03.K1
N$168
  Bottom 0.254: 104.68,118.86 95.03,118.86 94.02,117.84 C14.K2 | 104.68,118.86 105.7,117.84 C13.K2 | 104.68,118.86 120.94,118.86 121.96,117.84 C12.K2 122.97,117.34 123.48,117.34 125,115.81 129.07,115.81 129.58,116.32 134.15,116.32 134.66,116.83 C11.K2 135.67,117.34 137.2,115.81 142.78,115.81 143.8,116.83 147.36,116.83 C10.K2 148.37,117.34 148.88,117.34 150.4,115.81 154.47,115.81 154.98,116.32 159.55,116.32 160.06,116.83 C09.K2 161.07,117.34 162.09,116.32 166.15,116.32 166.66,115.81 167.68,115.81 168.69,116.83 175.8,116.83 C08.K2 176.82,117.84 177.84,118.86 187.49,118.86 | 187.49,118.86 188.5,117.84 C07.K2 | 200.19,118.86 201.2,117.84 C06.K2 | 187.49,118.86 200.19,118.86 | 212.89,118.86 213.9,117.84 C05.K2 | 200.19,118.86 212.89,118.86 | 228.64,118.86 229.65,117.84 C04.K2 | 212.89,118.86 228.64,118.86 | 241.34,118.86 242.35,117.84 C03.K2 | 228.64,118.86 241.34,118.86 | 254.04,118.86 255.05,117.84 C02.K2 | 241.34,118.86 254.04,118.86 | 254.04,118.86 266.74,118.86 267.75,117.84 C01.K2
N$169
  Bottom 0.254: 256.58,115.81 258.1,114.29 C02.L1 | 256.58,115.81 247.43,115.81 246.42,114.8 C03.L1 243.37,114.29 241.84,115.81 234.73,115.81 233.72,114.8 C04.L1 232.7,114.29 231.68,113.27 228.13,113.27 227.62,112.76 226.6,112.76 225.59,113.78 217.97,113.78 C05.L1 216.95,113.78 216.44,113.78 215.43,112.76 210.35,112.76 209.84,113.27 205.78,113.27 205.27,113.78 C06.L1 204.25,113.78 203.74,113.78 202.73,112.76 197.65,112.76 197.14,113.27 193.08,113.27 192.57,113.78 C07.L1 191.55,113.78 191.04,113.78 190.03,112.76 184.95,112.76 184.44,113.27 180.38,113.27 179.87,113.78 C08.L1 178.85,113.78 178.34,113.27 174.28,113.27 173.77,112.76 172.25,112.76 171.23,113.78 164.12,113.78 C09.L1 159.55,114.29 158.02,115.81 155.48,115.81 154.47,114.8 151.42,114.8 C10.L1 150.4,114.8 149.39,115.81 143.8,115.81 143.29,115.3 139.23,115.3 138.72,114.8 C11.L1 137.7,114.8 137.2,115.3 133.13,115.3 132.62,115.81 131.1,115.81 130.08,114.8 126.02,114.8 C12.L1 125,114.8 123.99,115.81 111.8,115.81 110.27,114.29 C13.L1 109.26,113.78 107.73,113.78 106.72,112.76 102.65,112.76 102.14,113.27 98.59,113.27 97.57,114.29 C14.L1 | 256.58,115.81 269.28,115.81 270.8,114.29 C01.L1
N$170  (via drill 0.61)
  Top 0.254: v120.94,108.7 119.42,110.22 119.42,113.78 C12.L2 | 239.3,112.76 232.7,112.76 232.19,113.27 232.19,113.78 227.62,113.78 C04.L2 | 239.3,112.76 239.3,113.78 C03.L2 | 239.3,112.76 246.92,112.76 247.43,113.27 247.43,113.78 252,113.78 C02.L2 253.02,113.78 253.02,112.76 259.62,112.76 260.13,113.27 260.13,113.78 264.7,113.78 C01.L2 | v161.07,115.3 161.07,114.8 157.52,114.8 C09.L2
  Bottom 0.254: C09.L2 154.47,114.29 152.94,112.76 145.83,112.76 144.82,113.78 C10.L2 143.8,114.29 142.78,113.27 139.23,113.27 138.72,112.76 134.66,112.76 133.64,113.78 132.12,113.78 C11.L2 129.07,114.29 127.54,112.76 120.43,112.76 119.42,113.78 C12.L2 | C13.L2 102.65,114.8 102.14,114.8 101.13,115.81 96.05,115.81 95.03,114.8 90.97,114.8 C14.L2 90.97,113.78 90.97,109.21 120.43,109.21 v120.94,108.7 | 200.7,115.81 199.17,114.29 C06.L2 | 200.7,115.81 209.84,115.81 210.86,114.8 C05.L2 211.87,114.29 212.89,115.3 216.44,115.3 216.95,115.81 221.02,115.81 222.03,114.8 226.6,114.8 C04.L2 | 200.7,115.81 191.55,115.81 191.04,115.3 187.49,115.3 186.47,114.29 C07.L2 185.46,114.8 183.93,114.8 182.92,115.81 178.85,115.81 178.34,115.3 174.79,115.3 173.77,114.29 C08.L2 167.17,114.29 165.64,115.81 161.58,115.81 v161.07,115.3
N$171
  Bottom 0.254: 111.29,109.72 101.64,109.72 100.62,110.73 C14.M1 | 111.29,109.72 112.3,110.73 C13.M1 | 111.29,109.72 127.04,109.72 128.05,110.73 C12.M1 129.07,110.73 130.08,109.72 139.74,109.72 | 139.74,109.72 140.75,110.73 C11.M1 | 152.44,109.72 153.45,110.73 C10.M1 | 152.44,109.72 139.74,109.72 | 165.14,109.72 166.15,110.73 C09.M1 | 152.44,109.72 165.14,109.72 | 180.88,109.72 181.9,110.73 C08.M1 | 165.14,109.72 180.88,109.72 | 193.58,109.72 194.6,110.73 C07.M1 | 180.88,109.72 193.58,109.72 | 206.28,109.72 207.3,110.73 C06.M1 | 193.58,109.72 206.28,109.72 | 218.98,109.72 220,110.73 C05.M1 | 206.28,109.72 218.98,109.72 | 235.24,109.72 236.26,110.73 C04.M1 | 218.98,109.72 235.24,109.72 | 247.94,109.72 248.96,110.73 C03.M1 | 235.24,109.72 247.94,109.72 | 260.64,109.72 261.66,110.73 C02.M1 | 247.94,109.72 260.64,109.72 | 260.64,109.72 273.34,109.72 274.36,110.73 C01.M1
N$172
  Bottom 0.254: 240.83,112.76 231.68,112.76 230.67,111.75 C04.M2 229.65,111.24 227.11,111.24 225.59,112.76 216.44,112.76 214.92,111.24 C05.M2 213.9,111.75 210.35,111.75 209.33,112.76 203.74,112.76 202.22,111.24 C06.M2 201.2,111.75 200.7,112.26 196.63,112.26 196.12,112.76 191.04,112.76 189.52,111.24 C07.M2 188.5,111.75 184.95,111.75 183.93,112.76 178.34,112.76 176.82,111.24 C08.M2 175.8,111.75 172.25,111.75 171.23,112.76 162.6,112.76 161.07,111.24 C09.M2 160.06,111.75 159.04,112.76 153.96,112.76 153.45,112.26 149.39,112.26 148.37,111.24 C10.M2 147.36,111.75 145.83,111.75 144.82,112.76 141.26,112.76 140.75,112.26 136.69,112.26 135.67,111.24 C11.M2 134.66,111.75 133.64,112.76 128.56,112.76 128.05,112.26 123.99,112.26 122.97,111.24 C12.M2 121.96,111.75 120.43,111.75 119.42,112.76 107.73,112.76 106.72,111.75 C13.M2 105.7,111.24 103.16,111.24 101.64,112.76 95.03,112.76 94.02,111.75 C14.M2 | 240.83,112.76 242.35,111.24 C03.M2 | 253.53,112.76 255.05,111.24 C02.M2 | 240.83,112.76 253.53,112.76 | 253.53,112.76 266.23,112.76 267.75,111.24 C01.M2
N$175  (via drill 0.61)
  Top 0.254: v122.97,103.11 128.05,103.11 128.05,104.64 C12.P1 | C07.P1 195.62,105.14 200.19,105.14 200.19,105.65 200.7,106.16 207.3,106.16 207.3,105.14 C06.P1 | C03.P1 249.97,105.14 254.04,105.14 255.05,106.16 261.66,106.16 261.66,105.14 C02.P1 | v175.3,106.16 181.9,106.16 181.9,105.14 C08.P1
  Bottom 0.254: C14.P1 100.62,104.64 102.14,103.11 110.78,103.11 111.8,104.13 112.3,104.13 C13.P1 113.32,104.64 114.34,103.62 120.94,103.62 121.45,103.11 v122.97,103.11 | 139.74,106.16 130.08,106.16 129.07,105.14 C12.P1 | 139.74,106.16 140.75,105.14 C11.P1 | 152.44,106.16 153.45,105.14 C10.P1 | 152.44,106.16 139.74,106.16 | 152.44,106.16 165.14,106.16 166.15,105.14 C09.P1 167.17,105.14 168.18,106.16 v175.3,106.16 | C08.P1 182.92,104.13 183.93,103.11 190.54,103.11 192.06,104.64 194.6,104.64 C07.P1 | C06.P1 208.32,104.13 208.82,103.62 213.4,103.62 213.9,103.11 215.94,103.11 217.46,104.64 220,104.64 C05.P1 221.02,104.13 222.03,103.11 233.72,103.11 234.73,104.13 236.26,104.13 C04.P1 237.27,104.64 238.29,103.62 242.35,103.62 242.86,103.11 247.94,103.11 248.96,104.13 C03.P1 | C02.P1 262.67,104.64 263.69,103.62 267.75,103.62 268.26,103.11 273.34,103.11 274.36,104.13 C01.P1
N$176
  Bottom 0.254: C14.P2 94.02,105.14 95.03,106.16 104.68,106.16 105.7,105.14 C13.P2 106.72,105.14 107.73,106.16 114.34,106.16 115.35,105.14 121.96,105.14 C12.P2 122.97,104.64 124.5,103.11 130.08,103.11 131.1,104.13 134.66,104.13 C11.P2 135.67,104.64 136.18,104.64 137.7,103.11 141.77,103.11 142.28,103.62 146.85,103.62 147.36,104.13 C10.P2 148.37,104.64 149.9,103.11 154.98,103.11 155.99,104.13 160.06,104.13 C09.P2 161.07,104.64 162.09,103.62 166.15,103.62 166.66,103.11 174.28,103.11 175.3,104.13 175.8,104.13 C08.P2 176.82,105.14 177.84,106.16 187.49,106.16 | 187.49,106.16 188.5,105.14 C07.P2 | 200.19,106.16 201.2,105.14 C06.P2 | 187.49,106.16 200.19,106.16 | 212.89,106.16 213.9,105.14 C05.P2 | 200.19,106.16 212.89,106.16 | 228.64,106.16 229.65,105.14 C04.P2 | 212.89,106.16 228.64,106.16 | 241.34,106.16 242.35,105.14 C03.P2 | 228.64,106.16 241.34,106.16 | 254.04,106.16 255.05,105.14 C02.P2 | 241.34,106.16 254.04,106.16 | 254.04,106.16 266.74,106.16 267.75,105.14 C01.P2
N$177
  Bottom 0.254: C01.R1 270.8,101.59 269.28,100.06 264.7,100.06 264.2,100.57 259.62,100.57 259.12,101.08 C02.R1 257.59,101.59 256.07,100.06 252,100.06 251.5,100.57 246.92,100.57 246.42,101.08 C03.R1 243.37,101.59 241.84,103.11 234.73,103.11 233.72,102.1 C04.R1 232.7,101.59 231.68,100.57 228.13,100.57 227.62,100.06 226.6,100.06 225.59,101.08 217.97,101.08 C05.R1 216.95,101.08 216.44,101.08 215.43,100.06 210.35,100.06 209.84,100.57 205.78,100.57 205.27,101.08 C06.R1 204.25,101.08 203.74,101.08 202.73,100.06 197.65,100.06 197.14,100.57 193.08,100.57 192.57,101.08 C07.R1 191.55,101.08 191.04,101.08 190.03,100.06 184.95,100.06 184.44,100.57 180.38,100.57 179.87,101.08 C08.R1 178.85,101.08 178.34,100.57 174.28,100.57 173.77,100.06 172.25,100.06 171.23,101.08 164.12,101.08 C09.R1 159.55,101.59 158.02,103.11 155.99,103.11 154.98,102.1 151.42,102.1 C10.R1 150.4,102.1 149.9,102.6 145.83,102.6 145.32,103.11 142.78,103.11 141.77,102.1 138.72,102.1 C11.R1 137.7,102.1 136.69,103.11 131.1,103.11 130.59,102.6 126.53,102.6 126.02,102.1 C12.R1 125,102.1 121.45,102.1 120.43,103.11 111.8,103.11 110.27,101.59 C13.R1 109.26,101.08 107.73,101.08 106.72,100.06 102.65,100.06 102.14,100.57 98.59,100.57 97.57,101.59 C14.R1
N$178  (via drill 0.61)
  Top 0.254: v102.14,96.51 102.14,100.57 102.65,101.08 C13.R2 | v120.94,96 119.42,97.52 119.42,101.08 C12.R2 | C04.R2 227.62,101.08 232.19,101.08 232.19,100.57 232.7,100.06 239.3,100.06 239.3,101.08 C03.R2 240.32,101.08 244.89,101.08 244.89,100.57 245.4,100.06 252,100.06 252,101.08 C02.R2 | v162.09,102.6 162.09,102.1 157.52,102.1 C09.R2
  Bottom 0.254: C09.R2 154.47,101.59 152.94,100.06 145.83,100.06 144.82,101.08 C10.R2 143.8,101.59 142.78,100.57 139.23,100.57 138.72,100.06 134.66,100.06 133.64,101.08 132.12,101.08 C11.R2 129.07,101.59 127.54,100.06 120.43,100.06 119.42,101.08 C12.R2 | C14.R2 90.97,102.1 91.98,103.11 101.13,103.11 102.14,102.1 102.65,102.1 C13.R2 | v102.14,96.51 120.43,96.51 v120.94,96 | 200.7,103.11 199.17,101.59 C06.R2 | 200.7,103.11 209.84,103.11 210.86,102.1 C05.R2 211.87,101.59 212.89,102.6 216.44,102.6 216.95,103.11 221.02,103.11 222.03,102.1 226.6,102.1 C04.R2 | 200.7,103.11 191.55,103.11 191.04,102.6 187.49,102.6 186.47,101.59 C07.R2 185.46,102.1 183.93,102.1 182.92,103.11 175.3,103.11 173.77,101.59 C08.R2 172.76,102.1 166.66,102.1 165.64,103.11 162.6,103.11 v162.09,102.6 | C02.R2 253.02,102.1 254.04,103.11 263.69,103.11 264.7,102.1 C01.R2
N$179
  Bottom 0.254: 111.29,97.02 105.7,97.02 105.19,97.52 101.13,97.52 100.62,98.03 C14.S1 | 111.29,97.02 112.3,98.03 C13.S1 | 111.29,97.02 127.04,97.02 128.05,98.03 C12.S1 129.07,98.03 130.08,97.02 139.74,97.02 | 139.74,97.02 140.75,98.03 C11.S1 | 152.44,97.02 153.45,98.03 C10.S1 | 152.44,97.02 139.74,97.02 | 165.14,97.02 166.15,98.03 C09.S1 | 165.14,97.02 152.44,97.02 | 180.88,97.02 181.9,98.03 C08.S1 | 165.14,97.02 180.88,97.02 | 193.58,97.02 194.6,98.03 C07.S1 | 180.88,97.02 193.58,97.02 | 206.28,97.02 207.3,98.03 C06.S1 | 193.58,97.02 206.28,97.02 | 218.98,97.02 220,98.03 C05.S1 | 206.28,97.02 218.98,97.02 | 235.24,97.02 236.26,98.03 C04.S1 | 218.98,97.02 235.24,97.02 | 247.94,97.02 248.96,98.03 C03.S1 | 235.24,97.02 247.94,97.02 | 260.64,97.02 261.66,98.03 C02.S1 | 247.94,97.02 260.64,97.02 | 260.64,97.02 273.34,97.02 274.36,98.03 C01.S1
N$180
  Bottom 0.254: C01.S2 267.75,98.54 265.21,98.54 263.69,100.06 257.08,100.06 256.07,99.05 C02.S2 255.05,98.54 254.04,99.56 250.48,99.56 249.97,100.06 240.83,100.06 | 240.83,100.06 231.68,100.06 230.67,99.05 C04.S2 229.65,98.54 227.11,98.54 225.59,100.06 216.44,100.06 214.92,98.54 C05.S2 213.9,99.05 210.35,99.05 209.33,100.06 203.74,100.06 202.22,98.54 C06.S2 201.2,99.05 200.7,99.56 196.63,99.56 196.12,100.06 191.04,100.06 189.52,98.54 C07.S2 188.5,99.05 184.95,99.05 183.93,100.06 178.34,100.06 176.82,98.54 C08.S2 175.8,99.05 172.25,99.05 171.23,100.06 162.6,100.06 161.07,98.54 C09.S2 160.06,99.05 159.04,100.06 153.96,100.06 153.45,99.56 149.39,99.56 148.37,98.54 C10.S2 147.36,99.05 145.83,99.05 144.82,100.06 141.26,100.06 140.75,99.56 136.69,99.56 135.67,98.54 C11.S2 134.66,99.05 133.64,100.06 128.56,100.06 128.05,99.56 123.99,99.56 122.97,98.54 C12.S2 121.96,99.05 120.43,99.05 119.42,100.06 107.73,100.06 106.72,99.05 C13.S2 105.7,98.54 103.16,98.54 101.64,100.06 95.03,100.06 94.02,99.05 C14.S2 | 240.83,100.06 242.35,98.54 C03.S2
N$183  (via drill 0.61)
  Top 0.254: v113.83,94.48 113.83,92.95 113.32,92.44 C13.U1 | C07.U1 195.62,92.44 195.62,93.46 202.22,93.46 203.24,92.44 207.3,92.44 C06.U1 208.32,92.44 212.89,92.44 212.89,92.95 213.4,93.46 220,93.46 220,92.44 C05.U1 | C02.U1 261.66,92.44 257.08,92.44 257.08,92.95 256.58,93.46 249.97,93.46 249.97,92.44 C03.U1 | v175.3,93.46 181.9,93.46 181.9,92.44 C08.U1
  Bottom 0.254: C14.U1 100.62,91.94 101.64,90.92 105.19,90.92 105.7,90.41 107.73,90.41 108.75,91.43 112.3,91.43 C13.U1 | 139.74,93.46 130.08,93.46 129.07,92.44 C12.U1 128.05,92.44 126.53,93.97 114.34,93.97 v113.83,94.48 | 139.74,93.46 140.75,92.44 C11.U1 | 152.44,93.46 153.45,92.44 C10.U1 | 152.44,93.46 139.74,93.46 | 152.44,93.46 165.14,93.46 166.15,92.44 C09.U1 167.17,92.44 168.18,93.46 v175.3,93.46 | C08.U1 182.92,91.43 183.93,90.41 193.08,90.41 194.6,91.94 C07.U1 | C02.U1 262.67,91.94 263.69,90.92 267.75,90.92 268.26,90.41 273.34,90.41 274.36,91.43 C01.U1 | 234.22,90.92 234.73,91.43 236.26,91.43 C04.U1 | 234.22,90.92 233.72,90.41 222.03,90.41 221.02,91.43 C05.U1 | 234.22,90.92 242.35,90.92 242.86,90.41 247.94,90.41 248.96,91.43 C03.U1
N$184
  Bottom 0.254: C14.U2 94.02,92.44 95.03,93.46 104.68,93.46 105.7,92.44 C13.U2 106.72,92.44 107.73,93.46 120.94,93.46 121.96,92.44 C12.U2 122.97,91.94 124.5,90.41 130.08,90.41 131.1,91.43 134.66,91.43 C11.U2 135.67,91.94 136.69,90.92 140.75,90.92 141.26,90.41 142.78,90.41 143.8,91.43 147.36,91.43 C10.U2 148.37,91.94 149.9,90.41 155.48,90.41 156.5,91.43 160.06,91.43 C09.U2 161.07,91.94 162.6,90.41 174.28,90.41 175.3,91.43 175.8,91.43 C08.U2 176.82,92.44 177.84,93.46 187.49,93.46 | 187.49,93.46 188.5,92.44 C07.U2 | 200.19,93.46 201.2,92.44 C06.U2 | 187.49,93.46 200.19,93.46 | 212.89,93.46 213.9,92.44 C05.U2 | 200.19,93.46 212.89,93.46 | 228.64,93.46 229.65,92.44 C04.U2 | 212.89,93.46 228.64,93.46 | 241.34,93.46 242.35,92.44 C03.U2 | 228.64,93.46 241.34,93.46 | 254.04,93.46 255.05,92.44 C02.U2 | 241.34,93.46 254.04,93.46 | 254.04,93.46 266.74,93.46 267.75,92.44 C01.U2
N$186  (via drill 0.61)
  Top 0.254: v106.21,86.35 109.26,89.4 C13.V1 | C03.V1 246.42,88.38 250.99,88.38 252,87.36 258.1,87.36 258.1,88.89 C02.V1 | v166.15,86.35 164.12,88.38 C09.V1
  Bottom 0.254: v106.21,86.35 104.68,86.35 103.67,87.36 99.1,87.36 97.57,88.89 C14.V1 | C09.V1 163.1,89.4 162.6,89.4 161.58,90.41 156.5,90.41 155.99,89.9 151.93,89.9 151.42,89.4 C10.V1 150.4,89.4 149.9,89.4 148.88,90.41 143.8,90.41 143.29,89.9 139.23,89.9 138.72,89.4 C11.V1 137.7,89.4 136.69,90.41 131.1,90.41 130.59,89.9 126.53,89.9 126.02,89.4 C12.V1 125,89.4 124.5,89.4 123.48,90.41 118.4,90.41 117.89,89.9 111.29,89.9 110.27,88.89 C13.V1 | 190.54,87.36 180.88,87.36 179.87,88.38 C08.V1 178.85,88.38 177.33,86.86 166.66,86.86 v166.15,86.35 | 190.54,87.36 191.55,88.38 C07.V1 | 203.24,87.36 204.25,88.38 C06.V1 | 190.54,87.36 203.24,87.36 | 203.24,87.36 215.94,87.36 216.95,88.38 C05.V1 217.97,88.38 219.49,86.86 256.07,86.86 258.1,88.89 C02.V1 259.12,88.38 260.13,87.36 269.28,87.36 270.8,88.89 C01.V1 | C04.V1 233.72,89.4 234.73,90.41 241.84,90.41 243.37,88.89 C03.V1
N$187
  Top 0.254: C07.V2 186.47,88.89 190.54,84.82 198.16,84.82 198.16,88.38 C06.V2
  Bottom 0.254: C06.V2 199.17,88.89 200.7,90.41 209.84,90.41 210.86,89.4 C05.V2 211.87,88.89 213.4,90.41 221.02,90.41 222.03,89.4 226.6,89.4 C04.V2 227.62,88.38 228.64,87.36 238.29,87.36 | 238.29,87.36 239.3,88.38 C03.V2 | 238.29,87.36 250.99,87.36 252,88.38 C02.V2 253.02,89.4 254.04,90.41 263.69,90.41 264.7,89.4 C01.V2 | C14.V2 90.97,89.4 91.48,89.9 95.54,89.9 96.05,90.41 98.59,90.41 99.6,89.4 102.65,89.4 C13.V2 103.67,88.38 104.68,87.36 120.43,87.36 | 120.43,87.36 119.42,88.38 C12.V2 | 129.58,87.36 120.43,87.36 | 129.58,87.36 131.1,88.89 C11.V2 | 142.28,87.36 143.8,88.89 C10.V2 | 142.28,87.36 129.58,87.36 | 154.98,87.36 156.5,88.89 C09.V2 | 154.98,87.36 142.28,87.36 | 154.98,87.36 171.74,87.36 172.76,88.38 C08.V2 173.77,88.89 175.3,90.41 179.87,90.41 180.38,89.9 184.95,89.9 185.46,89.4 C07.V2
N$188
  Bottom 0.254: D14.A1 100.62,73.14 102.14,74.66 108.24,74.66 109.26,73.65 112.3,73.65 D13.A1 113.32,73.14 114.84,74.66 126.53,74.66 128.05,73.14 D12.A1 129.07,72.63 130.08,71.62 139.74,71.62 | 139.74,71.62 140.75,72.63 D11.A1 | 139.74,71.62 152.44,71.62 153.45,72.63 D10.A1 154.47,73.65 155.48,74.66 164.63,74.66 | 164.63,74.66 166.15,73.14 D09.A1 | 180.38,74.66 181.9,73.14 D08.A1 | 180.38,74.66 164.63,74.66 | 193.08,74.66 194.6,73.14 D07.A1 | 180.38,74.66 193.08,74.66 | 205.78,74.66 207.3,73.14 D06.A1 | 193.08,74.66 205.78,74.66 | 218.48,74.66 220,73.14 D05.A1 | 205.78,74.66 218.48,74.66 | 235.24,74.66 236.26,73.65 D04.A1 | 218.48,74.66 235.24,74.66 | 235.24,74.66 247.94,74.66 248.96,73.65 D03.A1 249.97,72.63 250.99,71.62 260.64,71.62 | 260.64,71.62 261.66,72.63 D02.A1 | 260.64,71.62 273.34,71.62 274.36,72.63 D01.A1
N$190
  Bottom 0.254: 244.38,71.11 234.22,71.11 233.72,70.6 D04.B1 232.7,70.09 231.68,71.11 222.54,71.11 221.52,70.09 217.97,70.09 D05.B1 216.95,70.09 215.94,71.11 203.24,71.11 | 244.38,71.11 245.4,70.09 D03.B1 | 257.08,71.11 258.1,70.09 D02.B1 | 244.38,71.11 257.08,71.11 | 257.08,71.11 269.78,71.11 270.8,70.09 D01.B1 | 190.54,71.11 180.88,71.11 179.87,70.09 D08.B1 178.85,70.09 177.84,71.11 168.18,71.11 167.17,70.09 164.12,70.09 D09.B1 163.1,70.09 162.09,71.11 149.39,71.11 | 190.54,71.11 191.55,70.09 D07.B1 | 203.24,71.11 204.25,70.09 D06.B1 | 190.54,71.11 203.24,71.11 | D14.B1 97.57,70.09 98.59,71.11 108.75,71.11 109.26,70.6 D13.B1 110.27,70.09 116.88,70.09 117.89,71.11 127.04,71.11 | 127.04,71.11 126.02,70.09 D12.B1 | 136.69,71.11 127.04,71.11 | 136.69,71.11 137.7,70.09 D11.B1 | 149.39,71.11 150.4,70.09 D10.B1 | 149.39,71.11 136.69,71.11
N$196
  Bottom 0.254: D14.D2 90.97,64 91.48,64.5 95.54,64.5 96.05,65.01 98.59,65.01 99.6,64 102.65,64 D13.D2 103.67,64 104.18,64.5 108.24,64.5 108.75,65.01 111.29,65.01 112.81,63.49 D12.D2 119.42,64 120.43,65.01 129.58,65.01 | 129.58,65.01 131.1,63.49 D11.D2 | 142.28,65.01 143.8,63.49 D10.D2 | 142.28,65.01 129.58,65.01 | 154.98,65.01 156.5,63.49 D09.D2 | 154.98,65.01 142.28,65.01 | 171.74,65.01 172.76,64 D08.D2 | 171.74,65.01 154.98,65.01 | 184.44,65.01 185.46,64 D07.D2 | 184.44,65.01 171.74,65.01 | 197.14,65.01 198.16,64 D06.D2 | 197.14,65.01 184.44,65.01 | 209.84,65.01 210.86,64 D05.D2 | 197.14,65.01 209.84,65.01 | 225.59,65.01 226.6,64 D04.D2 | 209.84,65.01 225.59,65.01 | 238.29,65.01 239.3,64 D03.D2 | 225.59,65.01 238.29,65.01 | 250.99,65.01 252,64 D02.D2 | 238.29,65.01 250.99,65.01 | 250.99,65.01 263.69,65.01 264.7,64 D01.D2
N$198
  Bottom 0.254: D01.E2 267.75,60.44 265.21,60.44 263.69,61.96 257.08,61.96 256.07,60.95 D02.E2 255.05,60.44 254.04,61.46 250.48,61.46 249.97,61.96 244.38,61.96 243.37,60.95 D03.E2 242.35,60.44 239.81,60.44 238.29,61.96 231.68,61.96 230.67,60.95 D04.E2 229.65,60.44 223.05,60.44 221.52,61.96 216.44,61.96 214.92,60.44 D05.E2 213.9,60.95 210.35,60.95 209.33,61.96 203.74,61.96 202.22,60.44 D06.E2 201.2,60.95 200.7,61.46 196.63,61.46 196.12,61.96 191.04,61.96 189.52,60.44 D07.E2 188.5,60.95 184.95,60.95 183.93,61.96 178.34,61.96 176.82,60.44 D08.E2 175.8,60.95 172.25,60.95 171.23,61.96 162.6,61.96 161.07,60.44 D09.E2 160.06,60.95 156.5,60.95 155.48,61.96 149.9,61.96 148.37,60.44 D10.E2 147.36,60.95 143.8,60.95 142.78,61.96 137.2,61.96 135.67,60.44 D11.E2 134.66,60.95 131.1,60.95 130.08,61.96 124.5,61.96 122.97,60.44 D12.E2 121.96,60.95 118.4,60.95 117.38,61.96 107.73,61.96 106.72,60.95 D13.E2 105.7,60.44 103.16,60.44 101.64,61.96 95.03,61.96 94.02,60.95 D14.E2
N$202
  Bottom 0.254: 104.68,55.36 99.1,55.36 98.59,54.85 94.52,54.85 94.02,54.34 D14.H2 | 104.68,55.36 105.7,54.34 D13.H2 | 104.68,55.36 120.94,55.36 121.96,54.34 D12.H2 122.97,53.84 124.5,52.31 130.08,52.31 131.1,53.33 134.66,53.33 D11.H2 135.67,53.84 137.2,52.31 142.78,52.31 143.8,53.33 147.36,53.33 D10.H2 148.37,53.84 149.9,52.31 155.48,52.31 156.5,53.33 160.06,53.33 D09.H2 161.07,53.84 162.6,52.31 171.23,52.31 172.25,53.33 175.8,53.33 D08.H2 176.82,54.34 177.84,55.36 187.49,55.36 | 187.49,55.36 188.5,54.34 D07.H2 | 200.19,55.36 201.2,54.34 D06.H2 | 200.19,55.36 187.49,55.36 | 212.89,55.36 213.9,54.34 D05.H2 | 200.19,55.36 212.89,55.36 | 228.64,55.36 229.65,54.34 D04.H2 | 212.89,55.36 228.64,55.36 | 241.34,55.36 242.35,54.34 D03.H2 | 228.64,55.36 241.34,55.36 | 254.04,55.36 255.05,54.34 D02.H2 | 241.34,55.36 254.04,55.36 | 254.04,55.36 266.74,55.36 267.75,54.34 D01.H2
N$204
  Bottom 0.254: D14.J2 90.97,50.28 91.48,49.77 95.54,49.77 96.05,49.26 101.64,49.26 102.65,50.28 D13.J2 103.67,50.28 107.73,50.28 108.75,49.26 116.88,49.26 118.4,50.79 D12.J2 119.42,50.28 122.97,50.28 123.99,49.26 129.58,49.26 131.1,50.79 D11.J2 132.12,50.28 136.18,50.28 137.2,49.26 142.28,49.26 143.8,50.79 D10.J2 144.82,50.28 148.37,50.28 149.39,49.26 154.98,49.26 156.5,50.79 D09.J2 157.52,50.28 161.07,50.28 162.09,49.26 171.74,49.26 172.76,50.28 D08.J2 177.33,50.79 178.85,49.26 184.44,49.26 185.46,50.28 D07.J2 189.52,50.79 191.04,49.26 197.14,49.26 198.16,50.28 D06.J2 201.2,50.79 202.73,49.26 209.84,49.26 210.86,50.28 D05.J2 213.9,50.79 215.43,49.26 225.59,49.26 226.6,50.28 D04.J2 227.62,50.28 230.67,50.28 231.68,49.26 238.29,49.26 239.3,50.28 D03.J2 240.32,50.28 243.37,50.28 244.38,49.26 250.99,49.26 252,50.28 D02.J2 253.02,50.28 256.07,50.28 257.08,49.26 263.69,49.26 264.7,50.28 D01.J2
N$206
  Bottom 0.254: 104.68,46.22 95.03,46.22 94.02,47.23 D14.K2 | 104.68,46.22 105.7,47.23 D13.K2 | 120.94,46.22 121.96,47.23 D12.K2 | 120.94,46.22 104.68,46.22 | 133.64,46.22 134.66,47.23 D11.K2 | 133.64,46.22 120.94,46.22 | 146.34,46.22 147.36,47.23 D10.K2 | 146.34,46.22 133.64,46.22 | 159.04,46.22 160.06,47.23 D09.K2 | 159.04,46.22 146.34,46.22 | 174.79,46.22 175.8,47.23 D08.K2 | 174.79,46.22 159.04,46.22 | 187.49,46.22 188.5,47.23 D07.K2 | 187.49,46.22 174.79,46.22 | 200.19,46.22 201.2,47.23 D06.K2 | 200.19,46.22 187.49,46.22 | 212.89,46.22 213.9,47.23 D05.K2 | 212.89,46.22 200.19,46.22 | 228.64,46.22 229.65,47.23 D04.K2 | 212.89,46.22 228.64,46.22 | 241.34,46.22 242.35,47.23 D03.K2 | 228.64,46.22 241.34,46.22 | 254.04,46.22 255.05,47.23 D02.K2 | 241.34,46.22 254.04,46.22 | 254.04,46.22 266.74,46.22 267.75,47.23 D01.K2
N$208
  Bottom 0.254: 101.64,45.71 91.98,45.71 90.97,44.69 D14.L2 | 101.64,45.71 102.65,44.69 D13.L2 | 117.38,45.71 118.4,44.69 D12.L2 | 117.38,45.71 101.64,45.71 | 130.08,45.71 131.1,44.69 D11.L2 | 130.08,45.71 117.38,45.71 | 142.78,45.71 143.8,44.69 D10.L2 | 142.78,45.71 130.08,45.71 | 155.48,45.71 156.5,44.69 D09.L2 | 155.48,45.71 142.78,45.71 | 172.25,45.71 172.76,45.2 D08.L2 | 172.25,45.71 155.48,45.71 | 184.95,45.71 185.46,45.2 D07.L2 | 184.95,45.71 172.25,45.71 | 197.65,45.71 198.16,45.2 D06.L2 | 197.65,45.71 184.95,45.71 | 210.35,45.71 210.86,45.2 D05.L2 | 210.35,45.71 197.65,45.71 | 225.59,45.71 226.6,44.69 D04.L2 | 210.35,45.71 225.59,45.71 | 238.29,45.71 239.3,44.69 D03.L2 | 225.59,45.71 238.29,45.71 | 250.99,45.71 252,44.69 D02.L2 | 238.29,45.71 250.99,45.71 | 250.99,45.71 263.69,45.71 264.7,44.69 D01.L2
N$210
  Bottom 0.254: D14.M2 94.02,41.64 95.03,42.66 104.68,42.66 105.7,41.64 D13.M2 106.72,41.64 107.73,42.66 113.32,42.66 114.84,41.14 121.96,41.14 D12.M2 122.97,41.14 124.5,39.61 133.64,39.61 | 133.64,39.61 134.66,40.63 D11.M2 | 146.34,39.61 147.36,40.63 D10.M2 | 146.34,39.61 133.64,39.61 | 146.34,39.61 159.04,39.61 160.06,40.63 D09.M2 161.07,41.14 162.6,39.61 167.17,39.61 168.18,40.63 175.8,40.63 D08.M2 176.82,41.64 177.84,42.66 187.49,42.66 | 187.49,42.66 188.5,41.64 D07.M2 | 200.19,42.66 201.2,41.64 D06.M2 | 200.19,42.66 187.49,42.66 | 212.89,42.66 213.9,41.64 D05.M2 | 212.89,42.66 200.19,42.66 | 228.64,42.66 229.65,41.64 D04.M2 | 212.89,42.66 228.64,42.66 | 241.34,42.66 242.35,41.64 D03.M2 | 228.64,42.66 241.34,42.66 | 254.04,42.66 255.05,41.64 D02.M2 | 241.34,42.66 254.04,42.66 | 254.04,42.66 266.74,42.66 267.75,41.64 D01.M2
N$214
  Bottom 0.254: 104.18,36.56 95.03,36.56 94.02,35.55 D14.P2 | 104.18,36.56 105.7,35.04 D13.P2 | 120.94,36.56 121.96,35.55 D12.P2 | 120.94,36.56 104.18,36.56 | 133.64,36.56 134.66,35.55 D11.P2 | 133.64,36.56 120.94,36.56 | 146.34,36.56 147.36,35.55 D10.P2 | 146.34,36.56 133.64,36.56 | 159.04,36.56 160.06,35.55 D09.P2 | 159.04,36.56 146.34,36.56 | 174.79,36.56 175.8,35.55 D08.P2 | 174.79,36.56 159.04,36.56 | 187.49,36.56 188.5,35.55 D07.P2 | 187.49,36.56 174.79,36.56 | 200.19,36.56 201.2,35.55 D06.P2 | 200.19,36.56 187.49,36.56 | 212.89,36.56 213.9,35.55 D05.P2 | 212.89,36.56 200.19,36.56 | 228.13,36.56 229.65,35.04 D04.P2 | 228.13,36.56 212.89,36.56 | 240.83,36.56 242.35,35.04 D03.P2 | 228.13,36.56 240.83,36.56 | 253.53,36.56 255.05,35.04 D02.P2 | 240.83,36.56 253.53,36.56 | 253.53,36.56 266.23,36.56 267.75,35.04 D01.P2
N$215
  Bottom 0.254: 108.75,30.47 98.59,30.47 97.57,31.48 D14.R1 | 108.75,30.47 109.26,30.98 D13.R1 | 123.99,30.47 125,31.48 D12.R1 | 123.99,30.47 108.75,30.47 | 136.69,30.47 137.7,31.48 D11.R1 | 136.69,30.47 123.99,30.47 | 149.39,30.47 150.4,31.48 D10.R1 | 149.39,30.47 136.69,30.47 | 162.09,30.47 163.1,31.48 D09.R1 | 162.09,30.47 149.39,30.47 | 177.84,30.47 178.85,31.48 D08.R1 | 177.84,30.47 162.09,30.47 | 190.54,30.47 191.55,31.48 D07.R1 | 190.54,30.47 177.84,30.47 | 203.24,30.47 204.25,31.48 D06.R1 | 203.24,30.47 190.54,30.47 | 215.94,30.47 216.95,31.48 D05.R1 | 215.94,30.47 203.24,30.47 | 231.68,30.47 232.7,31.48 D04.R1 | 231.68,30.47 215.94,30.47 | 244.38,30.47 245.4,31.48 D03.R1 | 231.68,30.47 244.38,30.47 | 257.08,30.47 258.1,31.48 D02.R1 | 244.38,30.47 257.08,30.47 | 257.08,30.47 269.78,30.47 270.8,31.48 D01.R1
N$216
  Bottom 0.254: 101.64,33.01 91.98,33.01 90.97,31.99 D14.R2 | 101.64,33.01 102.65,31.99 D13.R2 | 117.38,33.01 118.4,31.99 D12.R2 | 117.38,33.01 101.64,33.01 | 130.08,33.01 131.1,31.99 D11.R2 | 130.08,33.01 117.38,33.01 | 142.78,33.01 143.8,31.99 D10.R2 | 142.78,33.01 130.08,33.01 | 155.48,33.01 156.5,31.99 D09.R2 | 155.48,33.01 142.78,33.01 | 172.25,33.01 172.76,32.5 D08.R2 | 172.25,33.01 155.48,33.01 | 184.95,33.01 185.46,32.5 D07.R2 | 184.95,33.01 172.25,33.01 | 197.65,33.01 198.16,32.5 D06.R2 | 197.65,33.01 184.95,33.01 | 210.35,33.01 210.86,32.5 D05.R2 | 210.35,33.01 197.65,33.01 | 225.59,33.01 226.6,31.99 D04.R2 | 225.59,33.01 210.35,33.01 | 238.29,33.01 239.3,31.99 D03.R2 | 225.59,33.01 238.29,33.01 | 250.99,33.01 252,31.99 D02.R2 | 238.29,33.01 250.99,33.01 | 250.99,33.01 263.69,33.01 264.7,31.99 D01.R2
N$218
  Bottom 0.254: 146.34,26.91 137.2,26.91 135.67,28.44 D11.S2 134.66,27.93 133.64,26.91 124.5,26.91 122.97,28.44 D12.S2 121.96,28.94 120.94,29.96 104.68,29.96 | 146.34,26.91 147.36,27.93 D10.S2 | 146.34,26.91 159.04,26.91 160.06,27.93 D09.S2 161.07,28.44 162.6,26.91 167.68,26.91 168.69,27.93 175.8,27.93 D08.S2 176.82,28.94 177.84,29.96 187.49,29.96 | 104.68,29.96 95.03,29.96 94.02,28.94 D14.S2 | 104.68,29.96 105.7,28.94 D13.S2 | 187.49,29.96 188.5,28.94 D07.S2 | 200.19,29.96 201.2,28.94 D06.S2 | 200.19,29.96 187.49,29.96 | 212.89,29.96 213.9,28.94 D05.S2 | 212.89,29.96 200.19,29.96 | 228.64,29.96 229.65,28.94 D04.S2 | 228.64,29.96 212.89,29.96 | 241.34,29.96 242.35,28.94 D03.S2 | 228.64,29.96 241.34,29.96 | 254.04,29.96 255.05,28.94 D02.S2 | 241.34,29.96 254.04,29.96 | 254.04,29.96 266.74,29.96 267.75,28.94 D01.S2
N$221
  Bottom 0.254: D14.U1 100.62,22.34 101.64,23.36 105.19,23.36 105.7,23.86 107.73,23.86 108.75,22.85 112.3,22.85 D13.U1 113.32,22.34 114.84,23.86 130.08,23.86 | 130.08,23.86 129.07,22.85 D12.U1 | 139.23,23.86 130.08,23.86 | 139.23,23.86 140.75,22.34 D11.U1 | 151.93,23.86 153.45,22.34 D10.U1 | 151.93,23.86 139.23,23.86 | 164.63,23.86 166.15,22.34 D09.U1 | 164.63,23.86 151.93,23.86 | 180.38,23.86 181.9,22.34 D08.U1 | 180.38,23.86 164.63,23.86 | 193.08,23.86 194.6,22.34 D07.U1 | 193.08,23.86 180.38,23.86 | 205.78,23.86 207.3,22.34 D06.U1 | 205.78,23.86 193.08,23.86 | 218.48,23.86 220,22.34 D05.U1 | 218.48,23.86 205.78,23.86 | 235.24,23.86 236.26,22.85 D04.U1 | 235.24,23.86 218.48,23.86 | 247.94,23.86 248.96,22.85 D03.U1 | 235.24,23.86 247.94,23.86 | 260.64,23.86 261.66,22.85 D02.U1 | 247.94,23.86 260.64,23.86 | 260.64,23.86 273.34,23.86 274.36,22.85 D01.U1
N$222
  Bottom 0.254: 104.68,20.82 95.03,20.82 94.02,21.83 D14.U2 | 104.68,20.82 105.7,21.83 D13.U2 | 120.94,20.82 121.96,21.83 D12.U2 | 120.94,20.82 104.68,20.82 | 133.64,20.82 134.66,21.83 D11.U2 | 133.64,20.82 120.94,20.82 | 146.34,20.82 147.36,21.83 D10.U2 | 146.34,20.82 133.64,20.82 | 159.04,20.82 160.06,21.83 D09.U2 | 159.04,20.82 146.34,20.82 | 174.79,20.82 175.8,21.83 D08.U2 | 174.79,20.82 159.04,20.82 | 187.49,20.82 188.5,21.83 D07.U2 | 187.49,20.82 174.79,20.82 | 200.19,20.82 201.2,21.83 D06.U2 | 200.19,20.82 187.49,20.82 | 212.89,20.82 213.9,21.83 D05.U2 | 212.89,20.82 200.19,20.82 | 228.64,20.82 229.65,21.83 D04.U2 | 228.64,20.82 212.89,20.82 | 241.34,20.82 242.35,21.83 D03.U2 | 241.34,20.82 228.64,20.82 | 254.04,20.82 255.05,21.83 D02.U2 | 241.34,20.82 254.04,20.82 | 254.04,20.82 266.74,20.82 267.75,21.83 D01.U2
N$223
  Bottom 0.254: 108.75,17.77 98.59,17.77 97.57,18.78 D14.V1 | 108.75,17.77 109.26,18.28 D13.V1 | 123.99,17.77 125,18.78 D12.V1 | 123.99,17.77 108.75,17.77 | 136.69,17.77 137.7,18.78 D11.V1 | 136.69,17.77 123.99,17.77 | 149.39,17.77 150.4,18.78 D10.V1 | 149.39,17.77 136.69,17.77 | 162.09,17.77 163.1,18.78 D09.V1 | 162.09,17.77 149.39,17.77 | 177.84,17.77 178.85,18.78 D08.V1 | 177.84,17.77 162.09,17.77 | 190.54,17.77 191.55,18.78 D07.V1 | 190.54,17.77 177.84,17.77 | 203.24,17.77 204.25,18.78 D06.V1 | 203.24,17.77 190.54,17.77 | 215.94,17.77 216.95,18.78 D05.V1 | 215.94,17.77 203.24,17.77 | 231.68,17.77 232.7,18.78 D04.V1 | 231.68,17.77 215.94,17.77 | 244.38,17.77 245.4,18.78 D03.V1 | 244.38,17.77 231.68,17.77 | 257.08,17.77 258.1,18.78 D02.V1 | 244.38,17.77 257.08,17.77 | 257.08,17.77 269.78,17.77 270.8,18.78 D01.V1
N$224
  Bottom 0.254: 101.64,20.31 91.98,20.31 90.97,19.29 D14.V2 | 101.64,20.31 102.65,19.29 D13.V2 | 117.38,20.31 118.4,19.29 D12.V2 | 117.38,20.31 101.64,20.31 | 130.08,20.31 131.1,19.29 D11.V2 | 130.08,20.31 117.38,20.31 | 142.78,20.31 143.8,19.29 D10.V2 | 142.78,20.31 130.08,20.31 | 155.48,20.31 156.5,19.29 D09.V2 | 155.48,20.31 142.78,20.31 | 172.25,20.31 172.76,19.8 D08.V2 | 172.25,20.31 155.48,20.31 | 184.95,20.31 185.46,19.8 D07.V2 | 184.95,20.31 172.25,20.31 | 197.65,20.31 198.16,19.8 D06.V2 | 197.65,20.31 184.95,20.31 | 210.35,20.31 210.86,19.8 D05.V2 | 210.35,20.31 197.65,20.31 | 225.59,20.31 226.6,19.29 D04.V2 | 225.59,20.31 210.35,20.31 | 238.29,20.31 239.3,19.29 D03.V2 | 238.29,20.31 225.59,20.31 | 250.99,20.31 252,19.29 D02.V2 | 238.29,20.31 250.99,20.31 | 250.99,20.31 263.69,20.31 264.7,19.29 D01.V2
VCC  (via drill 0.61)