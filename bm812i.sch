# EAGLE board bm812i (EAGLE 4.11), part 3 of 5
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
GND (continued)
  Bottom 0.635: A14.F2 90.97,260.08 96.56,260.08 A14.F1 97.57,260.08 102.65,260.08 A13.F2 | A10.F1 151.42,260.08 156.5,260.08 A09.F2 157.52,260.08 163.1,260.08 A09.F1 164.12,260.08 172.76,260.08 A08.F2 | A12.F1 126.02,260.08 131.1,260.08 A11.F2 132.12,260.08 137.7,260.08 A11.F1 | A13.F1 110.27,260.08 118.4,260.08 A12.F2 | A06.F2 199.17,260.08 204.25,260.08 A06.F1 | A05.F1 217.97,260.08 226.6,260.08 A04.F2 | A14.C1 100.62,269.74 105.7,269.74 A13.C2 106.72,269.74 112.3,269.74 A13.C1 113.32,269.74 121.96,269.74 A12.C2 122.97,269.74 128.05,269.74 A12.C1 | A09.C2 161.07,269.74 166.15,269.74 A09.C1 167.17,269.23 175.8,269.23 A08.C2 | A05.C1 221.02,269.74 229.65,269.74 A04.C2 | A14.N2 90.97,240.78 96.56,240.78 A14.N1 A13.N2 103.67,240.78 109.26,240.78 A13.N1 A12.N2 119.42,240.78 125,240.78 A12.N1 | A09.N2 A10.N1 | A10.N2 A11.N1 137.7,240.78 132.12,240.78 A11.N2 | A08.N1 179.87,240.78 185.46,240.78 A07.N2 | A06.N2 198.16,240.78 192.57,240.78 A07.N1 | A06.N1 205.27,240.78 210.86,240.78 A05.N2 A05.N1 217.97,240.78 226.6,240.78 A04.N2 | A09.N1 164.12,240.78 172.76,240.78 A08.N2 | A15.C2 80.3,269.74 75.22,269.74 A16.C1 74.2,269.23 68.62,269.23 A16.C2 67.6,269.74 59.47,269.74 A17N.C1 58.46,269.23 52.87,269.23 A17N.C2 | A18N.C2 39.15,269.74 34.07,269.74 A19N.C1 33.06,269.23 27.47,269.23 A19N.C2 26.45,269.74 21.37,269.74 A20N.C1 20.36,269.23 14.77,269.23 A20N.C2 | A20N.R2 11.72,234.68 16.8,234.68 A20N.R1 | A20N.N2 A20N.N1 | A20N.F2 11.72,260.08 16.8,260.08 A20N.F1 17.82,260.08 23.4,260.08 A19N.F2 24.42,260.08 29.5,260.08 A19N.F1 30.52,260.08 36.1,260.08 A18N.F2 37.12,260.59 42.2,260.59 A18N.F1
  Bottom 0.635: A19N.R2 24.42,234.68 29.5,234.68 A19N.R1 | A19N.N2 A19N.N1 | A16.U2 68.62,226.05 70.65,228.08 71.16,228.08 A16.T1 72.17,228.59 73.7,227.06 82.84,227.06 83.86,228.08 A15.T1 A14.T2 90.97,228.08 96.56,228.08 A14.T1 A13.T2 103.67,228.08 109.26,228.08 A13.T1 A12.T2 119.42,228.08 125,228.08 A12.T1 A11.T2 132.12,228.08 137.7,228.08 A11.T1 A10.T2 | A17N.K1 59.47,250.43 62.01,247.89 64.55,247.89 A16.L2 | A16.F1 71.16,260.08 65.57,260.08 A16.F2 | A16.N1 71.16,240.78 65.57,240.78 A16.N2 | A18N.R2 37.12,235.19 42.2,235.19 A18N.R1 | A18N.N2 A18N.N1 43.22,240.78 48.8,240.78 A17N.N2 | A17N.R2 49.82,234.68 54.9,234.68 A17N.R1 55.92,234.68 64.55,234.68 A16.R2 | A09.T2 A10.T1 | A08.T1 179.87,228.08 185.46,228.08 A07.T2 | A06.T2 198.16,228.08 192.57,228.08 A07.T1 | A05.T2 210.86,228.08 205.27,228.08 A06.T1 | A05.T1 217.97,228.08 226.6,228.08 A04.T2 | A09.T1 164.12,228.08 172.76,228.08 A08.T2 | B14.N2 90.97,171.18 96.56,171.18 B14.N1 97.57,171.18 102.65,171.18 B13.N2 103.67,171.18 109.26,171.18 B13.N1 110.27,171.69 118.4,171.69 B12.N2 | B12.N1 126.02,171.18 131.1,171.18 B11.N2 132.12,171.18 137.7,171.18 B11.N1 138.72,171.18 143.8,171.18 B10.N2 144.82,171.18 150.4,171.18 B10.N1 151.42,171.18 156.5,171.18 B09.N2 157.52,171.18 163.1,171.18 B09.N1 164.12,171.18 172.76,171.18 B08.N2 173.77,171.18 178.85,171.18 B08.N1 | B06.N2 198.16,171.18 192.57,171.18 B07.N1 | B05.N2 210.86,171.18 205.27,171.18 B06.N1 | B04.N1 233.72,171.18 239.3,171.18 B03.N2 | B05.N1 217.97,171.18 226.6,171.18 B04.N2 | B08.T1 178.85,158.48 173.77,158.48 B08.T2 172.76,158.48 164.12,158.48 B09.T1 163.1,158.48 157.52,158.48 B09.T2 156.5,158.48 151.42,158.48 B10.T1 150.4,158.48 144.82,158.48 B10.T2 143.8,158.48 138.72,158.48 B11.T1 137.7,158.48 132.12,158.48 B11.T2
  Bottom 0.635: B07.T2 186.47,158.48 191.55,158.48 B07.T1 | B05.T2 210.86,158.48 205.27,158.48 B06.T1 | B04.T1 233.72,158.48 239.3,158.48 B03.T2 | B05.T1 217.97,158.48 226.6,158.48 B04.T2 | B12.T1 125,158.48 119.42,158.48 B12.T2 118.4,158.99 110.27,158.99 B13.T1 109.26,158.48 103.67,158.48 B13.T2 102.65,158.48 97.57,158.48 B14.T1 96.56,158.48 90.97,158.48 B14.T2 89.95,158.48 84.87,158.48 B15.T1 83.86,159.5 80.3,159.5 79.28,160.52 73.7,160.52 | B17.P1 57.95,167.63 55.92,165.6 B17.R1 | 73.7,160.52 72.17,158.99 B16.T1 | 73.7,160.52 64.55,160.52 63.54,159.5 56.42,159.5 55.92,158.99 B17.T1 | B14.F2 B14.F1 B13.F2 103.67,189.98 109.26,189.98 B13.F1 B12.F2 119.42,189.98 125,189.98 B12.F1 | B11.F2 132.12,189.98 137.7,189.98 B11.F1 B10.F2 144.82,189.98 150.4,189.98 B10.F1 B09.F2 157.52,189.98 163.1,189.98 B09.F1 164.12,189.98 172.76,189.98 B08.F2 B08.F1 | B06.F2 198.16,189.98 192.57,189.98 B07.F1 | B05.F2 210.86,189.98 205.27,189.98 B06.F1 | B04.F1 233.72,189.98 239.3,189.98 B03.F2 | B05.F1 217.97,189.98 226.6,189.98 B04.F2 | B20.C2 14.77,199.63 15.28,199.12 18.83,199.12 19.34,198.62 24.93,198.62 25.94,199.63 B19.C2 27.47,199.63 28.48,199.63 29.5,198.62 37.63,198.62 38.64,199.63 B18.C2 40.17,200.14 42.71,200.14 44.23,201.66 49.82,201.66 51.34,200.14 B17.C2 52.87,199.63 53.38,199.12 56.93,199.12 57.44,198.62 63.54,198.62 64.55,199.63 67.6,199.63 B16.C2 68.62,199.63 69.12,199.12 73.19,199.12 73.7,198.62 76.24,198.62 77.25,199.63 80.3,199.63 B15.C2 81.32,199.63 81.82,199.12 85.89,199.12 86.4,198.62 88.94,198.62 89.95,199.63 93,199.63 B14.C2 94.02,199.63 99.6,199.63 B14.C1 100.62,199.63 105.7,199.63 B13.C2 106.72,199.63 112.3,199.63 B13.C1 113.32,199.63 121.96,199.63 B12.C2
  Bottom 0.635: B03.C2 242.35,199.63 237.27,199.63 B04.C1 | B11.C2 135.67,199.63 140.75,199.63 B11.C1 141.77,199.63 147.36,199.63 B10.C2 | B10.C1 154.47,199.63 160.06,199.63 B09.C2 161.07,199.63 166.15,199.63 B09.C1 167.17,199.63 175.8,199.63 B08.C2 | B06.C2 202.22,199.63 207.3,199.63 B06.C1 208.32,199.63 213.9,199.63 B05.C2 | B07.C1 194.6,199.63 189.52,199.63 B07.C2 188.5,199.63 182.92,199.63 B08.C1 | B04.C2 229.65,199.63 221.02,199.63 B05.C1 | D14.N2 90.97,37.58 96.56,37.58 D14.N1 | D13.N2 103.67,37.58 109.26,37.58 D13.N1 D12.N2 119.42,37.58 125,37.58 D12.N1 | D09.N2 157.52,37.58 163.1,37.58 D09.N1 164.12,37.58 172.76,37.58 D08.N2 | D11.N1 D10.N2 144.82,37.58 150.4,37.58 D10.N1 | D06.N2 D06.N1 | D03.N2 D03.N1 | D07.T2 D07.T1 | D04.T2 D04.T1 | 53.38,23.86 44.23,23.86 43.22,24.88 D18.T1 | 53.38,23.86 54.9,25.39 D17.T1 | 53.38,23.86 66.08,23.86 67.09,24.88 71.16,24.88 D16.T1 72.17,25.39 72.68,24.88 76.24,24.88 77.25,23.86 82.84,23.86 83.86,24.88 D15.T1 D14.T2 90.97,24.88 96.56,24.88 D14.T1 | D13.T2 D13.T1 D12.T2 119.42,24.88 125,24.88 D12.T1 D11.T2 132.12,24.88 137.7,24.88 D11.T1 | D10.T2 144.82,24.88 150.4,24.88 D10.T1 D09.T2 157.52,24.88 163.1,24.88 D09.T1 164.12,24.88 172.76,24.88 D08.T2 | D14.F2 90.97,56.88 96.56,56.88 D14.F1 97.57,56.88 102.65,56.88 D13.F2 103.67,56.88 109.26,56.88 D13.F1 110.27,57.39 118.4,57.39 D12.F2 | D11.F1 138.72,56.88 143.8,56.88 D10.F2 144.82,56.88 150.4,56.88 D10.F1 151.42,56.88 156.5,56.88 D09.F2 157.52,56.88 163.1,56.88 D09.F1 164.12,56.88 172.76,56.88 D08.F2 173.77,57.39 178.85,57.39 D08.F1 | D01.F2 264.7,56.88 259.12,56.88 D02.F1
  Bottom 0.635: D05.F1 217.97,56.88 226.6,56.88 D04.F2 | D01.C1 274.36,66.03 268.77,66.03 D01.C2 | D05.C1 221.02,66.54 229.65,66.54 D04.C2 | D19.F1 30.52,57.9 30.52,61.96 32.55,61.96 37.12,66.54 39.15,66.54 D18.C2 40.17,66.03 44.23,66.03 45.25,65.01 47.79,65.01 49.31,66.54 51.85,66.54 D17.C2 52.87,67.04 53.88,68.06 66.58,68.06 67.6,67.04 D16.C2 68.62,66.03 69.63,65.01 78.78,65.01 80.3,66.54 D15.C2 81.32,66.03 82.33,65.01 88.94,65.01 90.46,66.54 93,66.54 D14.C2 94.02,66.54 99.6,66.54 D14.C1 100.62,66.54 105.7,66.54 D13.C2 | D10.C2 147.36,66.03 141.77,66.03 D11.C1 | D09.C2 160.06,66.03 154.47,66.03 D10.C1 | D13.C1 113.32,66.54 121.96,66.54 D12.C2 | D08.C2 175.8,66.03 167.17,66.03 D09.C1 | C14.N2 90.97,107.68 96.56,107.68 C14.N1 97.57,107.68 102.65,107.68 C13.N2 103.67,107.68 109.26,107.68 C13.N1 110.27,107.68 118.4,107.68 C12.N2 | C11.N2 132.12,107.68 137.7,107.68 C11.N1 138.72,107.68 143.8,107.68 C10.N2 144.82,107.68 150.4,107.68 C10.N1 151.42,107.68 156.5,107.68 C09.N2 157.52,107.68 163.1,107.68 C09.N1 164.12,107.68 172.76,107.68 C08.N2 173.77,107.68 178.85,107.68 C08.N1 | C05.N1 217.97,107.68 226.6,107.68 C04.N2 | C16.T1 72.17,95.49 73.7,97.02 79.28,97.02 80.81,95.49 83.86,95.49 C15.T1 84.87,95.49 89.95,95.49 C14.T2 90.97,94.98 96.56,94.98 C14.T1 97.57,94.98 102.65,94.98 C13.T2 103.67,94.98 109.26,94.98 C13.T1 110.27,95.49 118.4,95.49 C12.T2 119.42,94.98 125,94.98 C12.T1 126.02,94.98 131.1,94.98 C11.T2 | C09.T2 156.5,94.98 151.42,94.98 C10.T1 150.4,94.98 144.82,94.98 C10.T2 143.8,94.98 138.72,94.98 C11.T1 | C08.T1 178.85,94.98 173.77,94.98 C08.T2 172.76,94.98 164.12,94.98 C09.T1
  Bottom 0.635: C04.T1 232.7,94.98 227.62,94.98 C04.T2 226.6,94.98 217.97,94.98 C05.T1 | C14.F1 C14.F2 | C13.F2 C13.F1 C12.F2 119.42,126.48 125,126.48 C12.F1 | C11.F2 132.12,126.48 137.7,126.48 C11.F1 C10.F2 144.82,126.48 150.4,126.48 C10.F1 C09.F2 157.52,126.48 163.1,126.48 C09.F1 164.12,126.48 172.76,126.48 C08.F2 C08.F1 | C05.F1 217.97,126.48 226.6,126.48 C04.F2 | B20.V1 17.82,152.9 19.85,154.93 B20.U1 20.86,154.93 21.88,153.91 28.48,153.91 29.5,152.9 B19.V1 | B18.V1 42.2,152.9 41.18,153.91 37.63,153.91 36.61,154.93 33.56,154.93 B19.U1 | C20.C2 14.77,136.13 15.28,135.62 18.83,135.62 19.34,135.12 22.39,135.12 23.91,136.64 26.45,136.64 C19.C2 27.47,136.13 28.48,135.12 38.14,135.12 39.15,136.13 C18.C2 40.17,136.13 41.18,135.12 47.79,135.12 48.8,136.13 51.85,136.13 C17.C2 52.87,136.64 58.46,136.64 C17.C1 59.47,136.13 67.6,136.13 C16.C2 68.62,136.13 69.12,135.62 73.19,135.62 73.7,135.12 75.73,135.12 77.25,136.64 80.3,136.64 C15.C2 81.32,136.13 82.33,135.12 88.43,135.12 89.44,136.13 93,136.13 C14.C2 94.02,136.13 99.6,136.13 C14.C1 100.62,136.13 105.7,136.13 C13.C2 106.72,136.13 112.3,136.13 C13.C1 113.32,136.13 121.96,136.13 C12.C2 122.97,136.64 128.05,136.64 C12.C1 | C20.T1 17.82,96 18.83,97.02 27.98,97.02 29.5,95.49 C19.T1 30.52,96 31.53,97.02 40.68,97.02 42.2,95.49 C18.T1 43.22,94.98 48.8,94.98 C17.T2 49.82,94.98 54.9,94.98 C17.T1 | C11.C1 141.77,136.13 147.36,136.13 C10.C2 148.37,136.13 153.45,136.13 C10.C1 154.47,136.13 160.06,136.13 C09.C2 161.07,136.64 166.15,136.64 C09.C1 167.17,136.13 175.8,136.13 C08.C2 | C05.C1 221.02,136.13 229.65,136.13 C04.C2
N$1
  Top 0.254: 85.89,169.66 84.87,170.68 84.87,171.18 B15.N1 | 85.89,169.66 86.9,168.64 B15.P1 | B15.V1 84.36,152.9 84.87,153.4 84.87,156.96 85.38,157.47 85.38,163.56 84.36,164.58 B15.R1 84.36,165.6 84.36,168.14 85.89,169.66 | B15.H1 86.9,186.93 86.9,181.34 B15.K1 | B15.B1 83.86,202.68 83.86,197.6 B15.D1 84.36,196.08 84.36,194.55 85.38,193.54 85.38,185.92 84.36,184.9 B15.J1
  Bottom 0.254: B15.J1 84.36,183.38 86.4,181.34 86.9,181.34 B15.K1 86.9,180.33 86.9,178.3 84.87,176.26 84.36,176.26 84.36,172.2 B15.N1 | B15.C1 86.9,200.65 84.87,202.68 84.36,202.68 B15.B1
N$2
  Top 0.254: B15.U2 80.3,155.94 80.3,161.53 B15.S2 80.81,162.55 79.79,163.56 79.79,168.14 77.76,170.17 77.76,170.68 B15.N2 78.27,171.69 80.3,173.72 80.3,174.23 B15.M2 80.3,174.74 80.3,175.25 78.27,177.28 B15.L2 78.27,178.3 79.79,179.82 79.79,186.42 80.3,186.93 B15.H2 80.81,187.95 80.81,193.03 B15.E2
  Bottom 0.254: B15.T2 77.76,157.98 79.79,155.94 80.3,155.94 B15.U2 81.32,154.93 86.9,154.93 B15.U1 | B15.F2 78.27,189.98 82.33,189.98 82.84,189.47 82.84,187.95 81.32,187.95 B15.H2
N$4
  Top 0.254: C15.V1 84.36,89.4 85.38,90.41 85.38,100.06 84.36,101.08 C15.R1 84.87,101.59 86.9,103.62 86.9,104.13 C15.P1 | C15.D1 83.86,134.1 83.86,139.18 C15.B1 | 85.38,111.75 85.38,109.72 84.36,108.7 C15.N1 | 85.38,111.75 85.38,118.86 84.36,119.88 C15.J1 | 85.38,111.75 87.41,113.78 87.41,116.83 C15.K1 86.9,117.84 86.9,123.43 C15.H1 87.41,124.45 88.94,125.97 88.94,135.12 87.92,136.13 C15.C1
  Bottom 0.254: C15.C1 86.9,137.15 84.87,139.18 84.36,139.18 C15.B1 | C15.N1 84.36,107.18 86.4,105.14 86.9,105.14 C15.P1
N$6
  Top 0.254: 78.78,113.27 80.3,111.75 80.3,111.24 C15.M2 80.3,110.73 80.3,110.22 78.27,108.19 C15.N2 77.76,107.18 79.79,105.14 79.79,97.52 | 78.78,113.27 78.27,113.78 C15.L2 | 79.79,97.52 78.27,96 78.27,95.49 C15.T2 | 79.79,97.52 80.3,98.03 C15.S2 | 78.78,113.27 78.78,117.34 80.3,118.86 80.3,123.43 C15.H2
  Bottom 0.254: C15.H2 80.81,124.45 80.3,124.45 78.27,126.48 C15.F2 78.27,127.5 78.78,127.5 80.81,129.53 C15.E2 | C15.T2 77.76,94.48 79.79,92.44 80.3,92.44 C15.U2 81.32,91.43 86.9,91.43 C15.U1
N$8  (via drill 0.61)
  Top 0.254: D15.L2 77.76,45.2 76.24,46.72 76.24,61.96 77.25,62.98 D15.D2 78.27,64 82.33,64 82.33,72.12 | D15.H1 86.9,54.34 85.38,55.87 85.38,68.06 84.36,69.08 D15.B1 83.86,70.6 82.33,72.12 | v81.32,177.28 82.33,176.26 82.33,72.12
  Bottom 0.254: v81.32,177.28 76.24,182.36 67.6,182.36 67.09,181.85 59.47,181.85 58.96,181.34 B17.K1
N$10
  Bottom 0.254: 111.29,277.86 102.14,277.86 100.62,276.34 A14.A1 | 111.29,277.86 112.3,276.85 A13.A1 | 111.29,277.86 126.53,277.86 128.05,276.34 A12.A1 129.07,275.83 130.08,274.82 139.74,274.82 | 139.74,274.82 140.75,275.83 A11.A1 | 139.74,274.82 152.44,274.82 153.45,275.83 A10.A1 154.47,276.85 155.48,277.86 164.63,277.86 166.15,276.34 A09.A1 167.17,276.85 168.18,277.86 180.38,277.86 181.9,276.34 A08.A1 182.92,275.83 183.93,274.82 193.58,274.82 | 193.58,274.82 194.6,275.83 A07.A1 | 193.58,274.82 206.28,274.82 207.3,275.83 A06.A1 208.32,276.85 209.33,277.86 218.48,277.86 | 218.48,277.86 220,276.34 A05.A1 | 218.48,277.86 235.24,277.86 236.26,276.85 A04.A1 237.27,275.83 238.29,274.82 247.94,274.82 | 247.94,274.82 248.96,275.83 A03.A1 | 260.64,274.82 261.66,275.83 A02.A1 | 247.94,274.82 260.64,274.82 | 260.64,274.82 273.34,274.82 274.36,275.83 A01.A1
N$12  (via drill 0.61)
  Top 0.254: v20.86,184.39 20.86,186.93 B20.H1 | v84.36,179.82 85.38,178.8 v85.38,173.22 | v111.29,170.68 105.19,164.58 v105.19,149.34 | v143.8,150.36 145.83,148.32 v145.83,76.19 | v145.83,73.65 145.83,37.07 119.42,10.66 79.28,10.66 79.28,29.45 77.76,30.98 D15.R2
  Bottom 0.254: v20.86,184.39 22.39,182.87 39.15,182.87 41.69,185.41 78.78,185.41 v84.36,179.82 | v85.38,173.22 88.43,170.17 110.78,170.17 v111.29,170.68 | v105.19,149.34 105.7,148.83 110.78,148.83 112.3,150.36 v143.8,150.36 | v145.83,76.19 v145.83,73.65
N$14  (via drill 0.61)
  Top 0.254: v142.78,74.16 142.78,40.12 114.34,11.67 86.4,11.67 85.89,12.18 85.89,51.3 84.87,52.31 84.87,55.87 84.36,56.38 D15.F1 | v146.85,86.35 146.34,86.86 146.34,206.24 v143.8,208.78 | v136.69,215.89 136.18,216.4 136.18,258.56 118.91,275.83 v118.91,287.52 | v40.17,287.01 18.83,287.01 v18.83,238.75
  Bottom 0.254: v142.78,74.16 142.78,86.35 v146.85,86.35 | v136.69,215.89 v143.8,208.78 | v118.91,287.52 118.4,287.01 v40.17,287.01 | v18.83,238.75 16.8,236.72 6.13,236.72 4.1,234.68 4.1,207.76 10.7,207.76 12.74,205.73 12.74,205.22 13.24,204.71 14.77,204.71 15.78,205.73 19.85,205.73 B20.A1
N$15  (via drill 0.61)
  Top 0.254: v2.58,199.12 1.56,198.11 1.56,167.63 v2.07,167.12 | v5.12,161.02 v5.12,164.07 | v39.15,90.41 v39.15,85.84 | v49.31,76.7 50.84,75.17 50.84,71.62 53.88,68.57 53.88,64 v51.85,61.96 | v49.82,59.93 50.33,59.42 50.33,58.41 50.84,57.9 v50.84,51.3
  Bottom 0.254: v2.58,199.12 11.72,199.12 11.72,200.14 13.24,201.66 15.78,201.66 16.8,202.68 B20.B1 | v5.12,164.07 v2.07,167.12 | v5.12,161.02 5.12,156.45 2.07,156.45 1.56,155.94 1.56,90.41 v39.15,90.41 | v39.15,85.84 48.3,76.7 v49.31,76.7 | v51.85,61.96 v49.82,59.93 | v50.84,51.3 52.87,49.26 75.73,49.26 76.74,50.28 77.25,50.28 D15.J2
N$16  (via drill 0.61)
  Top 0.254: D15.S2 81.32,28.94 82.33,29.96 82.33,36.06 83.86,37.58 D15.N1 83.86,38.6 82.33,40.12 v82.33,43.68 | 66.58,64 70.14,64 70.14,68.06 71.16,69.08 D16.B1 | 66.58,64 65.57,64 D16.D2 | v50.33,164.07 50.33,178.8 51.85,180.33 B17.K2 | v83.35,160.52 82.84,160.01 82.84,73.65 v85.38,71.11 | v66.58,45.71 66.58,64
  Bottom 0.254: v50.33,164.07 50.84,163.56 52.87,163.56 53.38,163.06 53.38,162.04 56.42,162.04 57.95,163.56 77.25,163.56 80.3,160.52 v83.35,160.52 | v85.38,71.11 73.19,71.11 72.17,70.09 D16.B1 | v82.33,43.68 80.3,45.71 v66.58,45.71
N$17  (via drill 0.61)
  Top 0.254: v91.48,40.63 91.98,40.12 91.98,12.69 91.48,12.18 86.9,12.18 v86.9,12.69 | v21.88,12.18 5.12,28.94 5.12,63.49 3.08,65.52 3.08,154.42 3.59,154.93 3.59,175.25 4.1,175.76 4.1,184.39 v4.61,184.9 | v7.15,172.2 7.15,177.28 6.13,178.3 v6.13,180.84
  Bottom 0.254: v91.48,40.63 88.43,40.63 87.92,41.14 D15.M1 | v86.9,12.69 86.4,12.18 v21.88,12.18 | v4.61,184.9 1.56,181.85 1.56,172.2 v7.15,172.2 | v6.13,180.84 5.12,181.85 5.12,183.38 7.66,183.38 13.24,188.96 14.77,188.96 15.78,187.95 15.78,186.93 17.31,186.93 17.82,187.44 17.82,189.98 B20.F1
N$20  (via drill 0.61)
  Top 0.254: 25.44,174.23 25.94,174.23 B19.M2 | 25.44,174.23 23.91,174.23 21.88,172.2 21.88,164.58 22.39,164.07 22.39,160.52 23.4,159.5 B19.T2 | 25.44,183.38 29.5,183.38 B19.J1 | 25.44,183.38 25.44,174.23 | 25.44,183.38 25.44,188.46 23.91,189.98 B19.F2 | B19.J1 30.01,183.38 30.01,179.82 31.53,178.3 31.53,174.23 32.04,173.72 32.04,169.15 32.55,168.64 B19.P1 33.56,167.63 33.56,164.58 34.58,163.56 34.58,122.42 v35.09,121.91 | B19.C1 33.06,195.57 31.53,194.04 31.53,188.46 30.01,186.93 30.01,184.9 B19.J1
  Bottom 0.254: v35.09,121.91 63.54,121.91 64.55,120.89 C16.J2
N$21
  Top 0.254: D15.U2 81.32,22.85 82.84,24.37 82.84,29.96 83.86,30.98 D15.R1 | D16.K1 75.22,47.23 75.73,46.72 75.73,42.15 77.25,40.63 77.25,38.6 D15.N2 | C16.V2 64.55,88.38 64.04,87.87 64.04,78.73 64.55,78.22 64.55,71.62 63.54,70.6 63.54,60.44 65.06,58.92 65.06,57.9 D16.F2 65.06,56.38 63.54,54.85 63.54,43.68 64.04,43.17 64.04,39.1 64.55,38.6 D16.N2 | D15.D1 83.86,62.98 79.28,62.98 79.28,59.42 77.76,57.9 D15.F2
  Bottom 0.254: D16.U2 68.62,22.85 69.63,23.86 76.24,23.86 77.76,22.34 80.3,22.34 D15.U2 | 76.24,33.01 83.35,33.01 83.86,32.5 D15.R1 | 76.24,33.01 73.19,33.01 72.17,31.99 D16.R1 | 76.24,36.56 70.65,36.56 70.14,37.07 66.08,37.07 65.57,37.58 D16.N2 | 76.24,36.56 77.25,37.58 D15.N2 | D15.K1 86.9,48.25 86.4,48.76 82.33,48.76 81.82,49.26 76.74,49.26 75.22,47.74 D16.K1 | 76.24,33.01 76.24,36.56 | 69.12,58.92 70.65,60.44 70.65,62.98 71.16,62.98 D16.D1 | 69.12,58.92 68.11,57.9 66.08,57.9 65.57,57.39 D16.F2 | 69.12,58.92 75.73,58.92 77.25,57.39 D15.F2
N$22  (via drill 0.61)
  Top 0.254: 15.78,179.31 15.78,182.36 16.8,183.38 B20.J1 17.82,184.39 17.82,187.95 18.83,188.96 18.83,194.04 19.34,194.55 19.34,199.12 19.85,199.63 B20.C1 | 15.78,179.31 15.78,176.77 14.26,175.25 B20.M2 | v11.21,175.25 9.18,177.28 9.18,188.96 10.2,189.98 B20.F2 | v22.39,156.96 21.88,157.47 21.88,163.56 20.86,164.58 20.86,167.63 B20.P1 19.85,168.64 19.85,173.22 18.83,174.23 18.83,179.31 15.78,179.31 | v69.63,154.42 69.63,106.16 68.62,105.14 C16.P2
  Bottom 0.254: v11.21,175.25 13.75,175.25 B20.M2 | B20.T2 11.21,157.98 12.23,156.96 v22.39,156.96 22.9,157.47 53.38,157.47 53.88,156.96 69.63,156.96 v69.63,154.42
N$24  (via drill 0.61)
  Top 0.254: v14.77,171.18 15.28,170.68 15.28,144.26 15.78,143.75 15.78,135.12 v13.75,133.08 | v10.2,129.53 8.16,127.5 8.16,97.52 9.18,96.51 9.18,67.55 16.29,60.44 v16.29,22.85 | v81.82,16.24 83.86,18.28 D15.V1
  Bottom 0.254: v14.77,171.18 16.8,171.18 B20.N1 | v10.2,129.53 v13.75,133.08 | v16.29,22.85 22.9,16.24 v81.82,16.24
N$25  (via drill 0.61)
  Top 0.254: v58.96,51.3 57.44,52.82 57.44,56.88 v57.95,57.39 | v49.82,65.52 49.31,66.03 49.31,68.06 48.8,68.57 47.79,68.57 47.79,85.33 50.84,88.38 v50.84,89.4 | v5.12,151.37 5.12,159.5 6.13,160.52 v6.13,175.76 | v13.24,176.26 15.28,178.3 15.28,184.9 16.8,186.42 v16.8,187.95
  Bottom 0.254: v58.96,51.3 64.55,51.3 D16.J2 | v49.82,65.52 v57.95,57.39 | v50.84,89.4 46.77,93.46 6.13,93.46 3.08,96.51 3.08,151.37 v5.12,151.37 | v6.13,175.76 6.64,176.26 v13.24,176.26 | v16.8,187.95 13.24,191.5 13.24,193.54 B20.E2
N$26  (via drill 0.61)
  Top 0.254: v10.7,200.14 10.7,197.6 B20.D2 | v38.14,259.58 38.14,270.75 61.5,294.12 225.08,294.12 v225.08,172.2 | v154.47,172.71 152.44,170.68 v152.44,84.32 | v144.82,72.63 143.29,71.11 143.29,39.61 114.84,11.16 85.38,11.16 85.38,47.23 79.79,52.82 v79.79,56.38
  Bottom 0.254: v10.7,200.14 3.59,207.25 3.59,255.51 28.48,255.51 32.04,259.07 37.63,259.07 v38.14,259.58 | v225.08,172.2 224.57,172.71 v154.47,172.71 | v152.44,84.32 144.82,76.7 v144.82,72.63 | v79.79,56.38 79.28,55.87 73.19,55.87 72.17,56.88 D16.F1
N$27  (via drill 0.61)
  Top 0.254: v21.88,196.08 21.88,176.26 20.86,175.25 B20.M1 | v90.97,13.2 87.92,16.24 87.92,21.83 D15.U1
  Bottom 0.254: v21.88,196.08 21.37,195.57 4.61,195.57 1.56,198.62 1.56,291.07 96.56,291.07 99.1,293.61 272.83,293.61 282.99,283.45 282.99,12.18 91.98,12.18 v90.97,13.2
N$28
  Bottom 0.254: 244.38,274.31 234.22,274.31 233.72,273.8 A04.B1 232.7,273.29 231.68,274.31 222.54,274.31 221.52,273.29 217.97,273.29 A05.B1 216.95,273.29 215.94,274.31 203.24,274.31 | 244.38,274.31 245.4,273.29 A03.B1 | 257.08,274.31 258.1,273.29 A02.B1 | 244.38,274.31 257.08,274.31 | 257.08,274.31 269.78,274.31 270.8,273.29 A01.B1 | 190.54,274.31 180.88,274.31 179.87,273.29 A08.B1 178.85,273.29 177.84,274.31 168.18,274.31 167.17,273.29 164.12,273.29 A09.B1 163.1,273.29 162.09,274.31 149.39,274.31 | 190.54,274.31 191.55,273.29 A07.B1 | 203.24,274.31 204.25,273.29 A06.B1 | 203.24,274.31 190.54,274.31 | A14.B1 97.57,273.29 101.13,273.29 102.14,274.31 108.75,274.31 109.26,273.8 A13.B1 110.27,273.29 110.78,273.8 117.38,273.8 117.89,274.31 127.04,274.31 | 127.04,274.31 126.02,273.29 A12.B1 | 136.69,274.31 127.04,274.31 | 136.69,274.31 137.7,273.29 A11.B1 | 149.39,274.31 150.4,273.29 A10.B1 | 149.39,274.31 136.69,274.31
N$29  (via drill 0.61)
  Top 0.254: v16.29,161.53 15.78,161.02 15.78,144.77 16.29,144.26 v16.29,124.45 | v19.85,119.88 19.34,119.37 19.34,101.59 v20.86,100.06 | v27.47,100.06 28.48,99.05 28.48,64 28.99,63.49 28.99,54.34 31.53,51.8 31.53,50.28 32.04,49.77 32.04,32.5 v46.77,17.77
  Bottom 0.254: v16.29,161.53 14.77,161.53 B20.S2 | v16.29,124.45 16.29,119.37 19.34,119.37 v19.85,119.88 | v27.47,100.06 v20.86,100.06 | v46.77,17.77 69.63,17.77 70.14,18.28 71.16,18.28 D16.V1
N$30  (via drill 0.61)
  Top 0.254: v4.1,36.56 1.56,39.1 1.56,158.99 v2.07,159.5
  Bottom 0.254: v4.1,36.56 19.85,20.82 73.19,20.82 74.2,21.83 D16.U1 | v2.07,159.5 7.15,164.58 10.2,164.58 B20.R2
N$34
  Top 0.254: C19.M2 27.47,111.75 32.04,111.75 32.04,113.78 34.58,116.32 34.58,120.89 34.07,121.4 34.07,123.43 C19.H1
N$35  (via drill 0.61)
  Top 0.254: v70.65,118.86 70.14,119.37 70.14,150.86 71.16,151.88 B16.V1
  Bottom 0.254: v70.65,118.86 64.55,118.86 63.54,119.88 57.95,119.88 56.93,118.86 14.77,118.86 14.77,123.43 C20.H2
N$41  (via drill 0.61)
  Top 0.254: 69.63,29.96 70.14,30.47 70.14,36.56 71.16,37.58 D16.N1 71.66,38.6 71.66,39.1 72.68,40.12 72.68,51.8 74.2,53.33 D16.H1 | 69.63,29.96 68.62,28.94 D16.S2 | 69.63,29.96 66.58,33.01 66.58,42.15 65.06,43.68 D16.L2 | v59.47,209.79 53.88,204.2 53.88,173.22 54.9,172.2 B17.N1 | v58.96,217.41 56.93,219.44 v56.93,276.85 | v161.58,278.88 168.18,272.28 168.18,193.54 169.71,192.01 v169.71,16.75 | v70.65,17.26 69.63,18.28 69.63,29.96
  Bottom 0.254: v59.47,209.79 59.47,212.84 59.98,213.35 59.98,217.41 v58.96,217.41 | v56.93,276.85 58.46,278.37 136.69,278.37 137.2,278.88 v161.58,278.88 | v169.71,16.75 169.2,17.26 v70.65,17.26
N$46  (via drill 0.61)
  Top 0.254: v77.25,117.84 79.28,119.88 79.28,129.53 76.24,132.58 76.24,151.37 v74.2,153.4 | v68.11,159.5 67.09,160.52 67.09,186.42 67.6,186.93 B16.H2
  Bottom 0.254: v77.25,117.84 75.22,115.81 70.65,115.81 61.5,106.67 50.84,106.67 49.82,107.68 C17.N2 | v74.2,153.4 v68.11,159.5
N$49  (via drill 0.61)
  Top 0.254: A13.J2 103.67,253.48 108.24,253.48 108.24,252.97 108.75,252.46 118.4,252.46 118.4,253.99 A12.J2 | A04.J2 227.62,253.48 227.62,252.46 234.22,252.46 234.73,252.97 234.73,253.48 239.3,253.48 A03.J2 240.32,253.48 240.32,252.46 246.92,252.46 247.43,252.97 247.43,253.48 252,253.48 A02.J2 253.02,253.48 253.02,252.46 259.62,252.46 260.13,252.97 260.13,253.48 264.7,253.48 A01.J2 | v162.09,255 162.09,254.5 157.52,254.5 A09.J2
  Bottom 0.254: A09.J2 154.47,253.99 152.94,252.46 145.83,252.46 144.82,253.48 A10.J2 143.8,253.99 142.78,252.97 139.23,252.97 138.72,252.46 134.66,252.46 133.64,253.48 132.12,253.48 A11.J2 129.07,253.99 127.54,252.46 125,252.46 124.5,252.97 119.92,252.97 119.42,253.48 A12.J2 | A14.J2 90.97,254.5 91.98,255.51 101.64,255.51 102.65,254.5 A13.J2 | A04.J2 226.6,254.5 225.59,255.51 216.95,255.51 215.43,253.99 A05.J2 210.86,254.5 209.33,254.5 208.32,255.51 204.25,255.51 203.74,255 200.19,255 199.17,253.99 A06.J2 198.16,254.5 196.63,254.5 195.62,255.51 191.55,255.51 191.04,255 187.49,255 186.47,253.99 A07.J2 185.46,254.5 183.93,254.5 182.92,255.51 175.3,255.51 173.77,253.99 A08.J2 172.76,254.5 166.66,254.5 165.64,255.51 162.6,255.51 v162.09,255
N$62
  Bottom 0.254: A14.R1 97.57,234.68 98.59,233.67 106.72,233.67 107.22,234.18 109.26,234.18 A13.R1 110.27,234.68 111.29,233.67 127.04,233.67 | 127.04,233.67 126.02,234.68 A12.R1 | 127.04,233.67 136.69,233.67 | 136.69,233.67 137.7,234.68 A11.R1 | 149.39,233.67 150.4,234.68 A10.R1 | 136.69,233.67 149.39,233.67 | 162.09,233.67 163.1,234.68 A09.R1 | 149.39,233.67 162.09,233.67 | 177.84,233.67 178.85,234.68 A08.R1 | 162.09,233.67 177.84,233.67 | 190.54,233.67 191.55,234.68 A07.R1 | 177.84,233.67 190.54,233.67 | 203.24,233.67 204.25,234.68 A06.R1 | 190.54,233.67 203.24,233.67 | 215.94,233.67 216.95,234.68 A05.R1 | 203.24,233.67 215.94,233.67 | 231.68,233.67 232.7,234.68 A04.R1 | 215.94,233.67 231.68,233.67 | 244.38,233.67 245.4,234.68 A03.R1 | 231.68,233.67 244.38,233.67 | 257.08,233.67 258.1,234.68 A02.R1 | 244.38,233.67 257.08,233.67 | 257.08,233.67 269.78,233.67 270.8,234.68 A01.R1
N$64  (via drill 0.61)
  Top 0.254: v115.35,232.65 115.35,232.14 113.32,232.14 A13.S1 | v174.79,232.65 175.3,233.16 181.9,233.16 181.9,232.14 A08.S1
  Bottom 0.254: A14.S1 100.62,231.64 102.14,230.11 111.29,230.11 112.3,231.13 A13.S1 | 130.08,233.16 129.07,232.14 A12.S1 | 130.08,233.16 139.74,233.16 | 139.74,233.16 140.75,232.14 A11.S1 | 152.44,233.16 153.45,232.14 A10.S1 | 139.74,233.16 152.44,233.16 | 152.44,233.16 165.14,233.16 166.15,232.14 A09.S1 167.17,232.14 167.68,232.65 v174.79,232.65 | v115.35,232.65 115.86,233.16 130.08,233.16 | 193.08,230.11 183.93,230.11 182.92,231.13 A08.S1 | 193.08,230.11 194.6,231.64 A07.S1 | 205.78,230.11 207.3,231.64 A06.S1 | 193.08,230.11 205.78,230.11 | 218.48,230.11 220,231.64 A05.S1 | 205.78,230.11 218.48,230.11 | 235.24,230.11 236.26,231.13 A04.S1 | 218.48,230.11 235.24,230.11 | 247.94,230.11 248.96,231.13 A03.S1 | 235.24,230.11 247.94,230.11 | 260.64,230.11 261.66,231.13 A02.S1 | 247.94,230.11 260.64,230.11 | 260.64,230.11 273.34,230.11 274.36,231.13 A01.S1
N$67  (via drill 0.61)
  Top 0.254: v68.11,33.01 67.09,34.02 67.09,44.69 67.6,45.2 67.6,46.22 67.09,46.72 67.09,50.28 69.63,52.82 69.63,55.87 70.14,56.38 70.14,59.93 v71.66,61.46 | v74.2,64 76.24,66.03 76.24,88.89 v74.71,90.41 | v73.19,88.89 72.68,89.4 72.68,104.13 70.14,106.67 70.14,116.32 v70.65,116.83 | v52.87,115.81 53.88,116.83 v53.88,119.88 | v26.45,128 21.88,132.58 21.88,155.94 v19.85,157.98 | v14.26,158.99 12.74,160.52 12.74,163.06 v13.24,163.56 | v16.29,163.56 15.78,164.07 v15.78,175.25
  Bottom 0.254: v68.11,33.01 66.58,33.01 65.57,31.99 D16.R2 | v71.66,61.46 v74.2,64 | v74.71,90.41 v73.19,88.89 | v70.65,116.83 69.63,115.81 v52.87,115.81 | v53.88,119.88 53.38,119.37 28.99,119.37 28.48,119.88 28.48,128 v26.45,128 | v19.85,157.98 19.34,157.47 15.78,157.47 v14.26,158.99 | v13.24,163.56 v16.29,163.56 | v15.78,175.25 13.75,177.28 11.21,177.28 B20.L2
N$68  (via drill 0.61)
  Top 0.254: v72.68,28.94 72.68,39.1 74.2,40.63 D16.M1 | v10.7,84.32 11.21,84.82 11.21,86.86 12.74,88.38 12.74,103.11 9.18,106.67 9.18,122.92 12.74,126.48 12.74,128.51 v11.72,129.53 | v18.83,132.07 18.83,173.22 17.82,174.23 v17.82,175.76
  Bottom 0.254: v72.68,28.94 70.65,26.91 57.95,26.91 54.9,29.96 49.82,29.96 46.77,26.91 45.25,26.91 39.15,33.01 14.26,33.01 3.59,43.68 3.59,84.32 v10.7,84.32 | v11.72,129.53 14.26,132.07 v18.83,132.07 | v17.82,175.76 18.83,176.77 18.83,180.33 14.26,180.33 B20.K2
N$70
  Bottom 0.254: 111.29,224.02 101.64,224.02 100.62,225.03 A14.U1 | 111.29,224.02 112.3,225.03 A13.U1 | 127.04,224.02 128.05,225.03 A12.U1 | 111.29,224.02 127.04,224.02 | 139.74,224.02 140.75,225.03 A11.U1 | 127.04,224.02 139.74,224.02 | 152.44,224.02 153.45,225.03 A10.U1 | 139.74,224.02 152.44,224.02 | 165.14,224.02 166.15,225.03 A09.U1 | 152.44,224.02 165.14,224.02 | 180.88,224.02 181.9,225.03 A08.U1 | 165.14,224.02 180.88,224.02 | 193.58,224.02 194.6,225.03 A07.U1 | 180.88,224.02 193.58,224.02 | 206.28,224.02 207.3,225.03 A06.U1 | 193.58,224.02 206.28,224.02 | 218.98,224.02 220,225.03 A05.U1 | 206.28,224.02 218.98,224.02 | 235.24,224.02 236.26,225.03 A04.U1 | 218.98,224.02 235.24,224.02 | 247.94,224.02 248.96,225.03 A03.U1 | 235.24,224.02 247.94,224.02 | 260.64,224.02 261.66,225.03 A02.U1 | 247.94,224.02 260.64,224.02 | 260.64,224.02 273.34,224.02 274.36,225.03 A01.U1
N$72
  Bottom 0.254: 108.75,220.97 98.59,220.97 97.57,221.98 A14.V1 | 108.75,220.97 109.26,221.48 A13.V1 | 123.99,220.97 125,221.98 A12.V1 | 108.75,220.97 123.99,220.97 | 136.69,220.97 137.7,221.98 A11.V1 | 123.99,220.97 136.69,220.97 | 149.39,220.97 150.4,221.98 A10.V1 | 136.69,220.97 149.39,220.97 | 162.09,220.97 163.1,221.98 A09.V1 | 149.39,220.97 162.09,220.97 | 177.84,220.97 178.85,221.98 A08.V1 | 162.09,220.97 177.84,220.97 | 190.54,220.97 191.55,221.98 A07.V1 | 177.84,220.97 190.54,220.97 | 203.24,220.97 204.25,221.98 A06.V1 | 190.54,220.97 203.24,220.97 | 215.94,220.97 216.95,221.98 A05.V1 | 203.24,220.97 215.94,220.97 | 231.68,220.97 232.7,221.98 A04.V1 | 215.94,220.97 231.68,220.97 | 244.38,220.97 245.4,221.98 A03.V1 | 231.68,220.97 244.38,220.97 | 257.08,220.97 258.1,221.98 A02.V1 | 244.38,220.97 257.08,220.97 | 257.08,220.97 269.78,220.97 270.8,221.98 A01.V1
N$73  (via drill 0.61)
  Top 0.254: v35.09,111.75 35.09,75.17 33.56,73.65 D19.A1 | v24.42,135.62 25.44,136.64 25.44,139.18 28.48,142.23 28.48,143.75 27.98,144.26 27.98,165.6 v27.47,166.1 | v51.34,166.61 50.84,167.12 50.84,177.79 v51.34,178.3 | v45.25,184.39 50.33,189.47 50.33,209.79 48.3,211.82 v48.3,216.9 | v64.55,209.79 66.58,207.76 66.58,202.68 v64.55,200.65
  Bottom 0.254: v35.09,111.75 31.02,115.81 13.75,115.81 8.16,121.4 8.16,128.51 16.8,128.51 23.91,135.62 v24.42,135.62 | v27.47,166.1 31.02,169.66 40.68,169.66 43.72,166.61 v51.34,166.61 | v45.25,184.39 v51.34,178.3 | v48.3,216.9 51.34,219.95 62.52,219.95 64.04,218.43 64.04,209.79 v64.55,209.79 | v64.55,200.65 58.96,200.65 B17.C1
N$74
  Bottom 0.254: 101.64,223.51 91.98,223.51 90.97,222.49 A14.V2 | 101.64,223.51 102.65,222.49 A13.V2 | 117.38,223.51 118.4,222.49 A12.V2 | 101.64,223.51 117.38,223.51 | 130.08,223.51 131.1,222.49 A11.V2 | 117.38,223.51 130.08,223.51 | 142.78,223.51 143.8,222.49 A10.V2 | 130.08,223.51 142.78,223.51 | 155.48,223.51 156.5,222.49 A09.V2 | 142.78,223.51 155.48,223.51 | 172.25,223.51 172.76,223 A08.V2 | 155.48,223.51 172.25,223.51 | 184.95,223.51 185.46,223 A07.V2 | 172.25,223.51 184.95,223.51 | 197.65,223.51 198.16,223 A06.V2 | 184.95,223.51 197.65,223.51 | 210.35,223.51 210.86,223 A05.V2 | 197.65,223.51 210.35,223.51 | 225.59,223.51 226.6,222.49 A04.V2 | 210.35,223.51 225.59,223.51 | 238.29,223.51 239.3,222.49 A03.V2 | 225.59,223.51 238.29,223.51 | 250.99,223.51 252,222.49 A02.V2 | 238.29,223.51 250.99,223.51 | 250.99,223.51 263.69,223.51 264.7,222.49 A01.V2
N$75
  Top 0.254: B07.A1 195.62,206.74 200.19,211.32 207.3,211.32 207.3,206.74 B06.A1
  Bottom 0.254: B06.A1 208.32,205.73 211.87,205.73 212.89,204.71 214.41,204.71 214.92,205.22 218.98,205.22 220,206.24 B05.A1 221.02,205.73 221.52,205.22 229.65,205.22 230.16,204.71 238.8,204.71 | 238.8,204.71 237.27,206.24 B04.A1 | 238.8,204.71 243.88,204.71 244.89,205.73 248.96,205.73 B03.A1 249.97,206.24 251.5,204.71 264.2,204.71 | 264.2,204.71 262.67,206.24 B02.A1 | 264.2,204.71 273.34,204.71 274.36,205.73 B01.A1 | 111.29,207.76 105.7,207.76 105.19,207.25 101.13,207.25 100.62,206.74 B14.A1 | 111.29,207.76 112.3,206.74 B13.A1 | 127.04,207.76 128.05,206.74 B12.A1 | 111.29,207.76 127.04,207.76 | 127.04,207.76 139.74,207.76 140.75,206.74 B11.A1 141.77,206.24 143.29,206.24 144.82,207.76 152.44,207.76 153.45,206.74 B10.A1 154.47,206.24 155.99,206.24 157.52,207.76 165.14,207.76 | 165.14,207.76 166.15,206.74 B09.A1 | 165.14,207.76 180.88,207.76 181.9,206.74 B08.A1 182.92,205.73 187.49,205.73 188.5,204.71 189.01,204.71 189.52,205.22 193.58,205.22 194.6,206.24 B07.A1
N$77
  Bottom 0.254: 243.88,201.66 234.73,201.66 233.72,202.68 B04.B1 232.7,203.19 231.68,204.2 228.13,204.2 227.62,204.71 218.98,204.71 217.97,203.7 B05.B1 216.95,203.7 216.44,204.2 212.38,204.2 211.87,204.71 203.24,204.71 | 243.88,201.66 245.4,203.19 B03.B1 | 256.58,201.66 258.1,203.19 B02.B1 | 243.88,201.66 256.58,201.66 | 256.58,201.66 269.28,201.66 270.8,203.19 B01.B1 | 203.24,204.71 204.25,203.7 B06.B1 | 203.24,204.71 193.58,204.71 192.57,203.7 B07.B1 191.55,203.7 188.5,203.7 187.49,204.71 180.88,204.71 179.87,203.7 B08.B1 178.85,203.7 177.84,204.71 168.69,204.71 167.68,203.7 164.12,203.7 B09.B1 163.1,203.7 162.6,203.7 161.58,204.71 152.44,204.71 151.42,203.7 B10.B1 150.4,203.7 149.39,204.71 142.78,204.71 141.77,203.7 138.72,203.7 B11.B1 137.7,203.7 133.64,203.7 132.62,204.71 131.1,204.71 130.59,204.2 126.53,204.2 126.02,203.7 B12.B1 125,203.7 121.45,203.7 120.43,204.71 115.35,204.71 114.34,203.7 110.78,203.7 110.27,203.19 B13.B1 109.26,203.7 104.68,203.7 103.67,204.71 102.65,204.71 102.14,204.2 98.59,204.2 97.57,203.19 B14.B1
N$82
  Bottom 0.254: B14.D2 90.97,197.09 91.98,198.11 100.11,198.11 101.13,197.09 102.65,197.09 B13.D2 103.67,197.09 104.68,198.11 112.81,198.11 113.83,197.09 118.4,197.09 B12.D2 119.42,197.6 119.92,198.11 130.08,198.11 | 130.08,198.11 131.1,197.09 B11.D2 | 142.78,198.11 143.8,197.09 B10.D2 | 130.08,198.11 142.78,198.11 | 142.78,198.11 155.48,198.11 156.5,197.09 B09.D2 157.52,197.6 158.02,198.11 170.22,198.11 170.72,197.6 172.76,197.6 B08.D2 173.77,197.09 174.79,198.11 184.95,198.11 | 184.95,198.11 185.46,197.6 B07.D2 | 197.65,198.11 198.16,197.6 B06.D2 | 184.95,198.11 197.65,198.11 | 210.35,198.11 210.86,197.6 B05.D2 | 197.65,198.11 210.35,198.11 | 225.59,198.11 226.6,197.09 B04.D2 | 210.35,198.11 225.59,198.11 | 238.29,198.11 239.3,197.09 B03.D2 | 225.59,198.11 238.29,198.11 | 250.99,198.11 252,197.09 B02.D2 | 238.29,198.11 250.99,198.11 | 250.99,198.11 263.69,198.11 264.7,197.09 B01.D2
N$85
  Bottom 0.254: 104.68,195.06 95.03,195.06 94.02,194.04 B14.E2 | 104.68,195.06 105.7,194.04 B13.E2 | 104.68,195.06 113.32,195.06 114.84,193.54 121.96,193.54 B12.E2 122.97,193.54 125.51,193.54 127.04,192.01 129.07,192.01 129.58,192.52 134.15,192.52 134.66,193.03 B11.E2 135.67,193.54 136.69,192.52 140.75,192.52 141.26,192.01 141.77,192.01 142.78,193.03 147.36,193.03 B10.E2 148.37,193.54 149.9,192.01 159.04,192.01 160.06,193.03 B09.E2 161.07,193.54 162.6,192.01 167.68,192.01 168.69,193.03 175.8,193.03 B08.E2 176.82,194.04 177.84,195.06 187.49,195.06 | 187.49,195.06 188.5,194.04 B07.E2 | 200.19,195.06 201.2,194.04 B06.E2 | 187.49,195.06 200.19,195.06 | 212.89,195.06 213.9,194.04 B05.E2 | 200.19,195.06 212.89,195.06 | 228.64,195.06 229.65,194.04 B04.E2 | 212.89,195.06 228.64,195.06 | 241.34,195.06 242.35,194.04 B03.E2 | 228.64,195.06 241.34,195.06 | 254.04,195.06 255.05,194.04 B02.E2 | 241.34,195.06 254.04,195.06 | 254.04,195.06 266.74,195.06 267.75,194.04 B01.E2
N$89
  Bottom 0.254: B14.H2 94.02,187.95 94.52,188.46 99.1,188.46 99.6,188.96 101.13,188.96 102.65,187.44 105.7,187.44 B13.H2 106.72,187.95 107.73,188.96 124.5,188.96 | 124.5,188.96 122.97,187.44 B12.H2 | 124.5,188.96 133.64,188.96 | 133.64,188.96 134.66,187.95 B11.H2 | 146.34,188.96 147.36,187.95 B10.H2 | 133.64,188.96 146.34,188.96 | 159.04,188.96 160.06,187.95 B09.H2 | 146.34,188.96 159.04,188.96 | 174.79,188.96 175.8,187.95 B08.H2 | 159.04,188.96 174.79,188.96 | 187.49,188.96 188.5,187.95 B07.H2 | 174.79,188.96 187.49,188.96 | 200.19,188.96 201.2,187.95 B06.H2 | 187.49,188.96 200.19,188.96 | 212.89,188.96 213.9,187.95 B05.H2 | 200.19,188.96 212.89,188.96 | 228.13,188.96 229.65,187.44 B04.H2 | 212.89,188.96 228.13,188.96 | 240.83,188.96 242.35,187.44 B03.H2 | 228.13,188.96 240.83,188.96 | 253.53,188.96 255.05,187.44 B02.H2 | 240.83,188.96 253.53,188.96 | 253.53,188.96 266.23,188.96 267.75,187.44 B01.H2
N$91
  Top 0.254: C20.K2 14.77,117.84 15.78,118.86 15.78,122.42 20.36,126.99 20.36,129.53 C20.E1
N$92  (via drill 0.61)
  Top 0.254: v67.09,85.84 68.62,87.36 74.2,87.36 v74.2,87.87 | v102.14,86.35 101.64,86.86 101.64,89.4 104.68,92.44 104.68,119.88 107.73,122.92 107.73,139.18 102.65,144.26 v102.65,148.83 | v89.44,149.34 88.94,149.85 v88.94,164.07 | v70.65,166.61 69.63,167.63 69.63,173.22 68.62,174.23 B16.M2
  Bottom 0.254: v67.09,85.84 64.55,85.84 59.98,90.41 53.88,90.41 52.87,91.43 C17.U2 | v74.2,87.87 76.74,90.41 79.28,90.41 82.33,87.36 98.08,87.36 99.1,86.35 v102.14,86.35 | v102.65,148.83 102.14,149.34 v89.44,149.34 | v88.94,164.07 86.4,166.61 v70.65,166.61
N$93
  Top 0.254: C20.N2 11.72,108.19 16.29,108.19 16.29,116.32 18.83,118.86 18.83,121.91 20.36,123.43 C20.H1
N$94  (via drill 0.61)
  Top 0.254: v37.12,143.24 37.63,143.75 37.63,159.5 36.61,160.52 36.61,164.58 B18.R2 | v73.7,141.21 73.19,141.72 73.19,153.91 74.2,154.93 B16.U1
  Bottom 0.254: v37.12,143.24 39.15,141.21 v73.7,141.21
N$96  (via drill 0.61)
  Top 0.254: v45.76,68.57 46.77,69.58 46.77,71.11 45.76,71.11 44.74,72.12 44.74,99.56 47.28,102.1 47.28,123.94 49.82,123.94 50.33,123.43 50.33,122.42 49.31,121.4 C17.J2 | v20.86,69.08 19.34,67.55 19.34,17.77 34.58,2.53 190.54,2.53 190.54,26.4 223.56,59.42 223.56,277.36 v209.33,291.58 | v101.13,292.6 82.84,274.31 82.84,268.21 83.86,267.2 A15.D1
  Bottom 0.254: v45.76,68.57 21.37,68.57 v20.86,69.08 | v209.33,291.58 208.32,292.6 v101.13,292.6
N$97
  Top 0.254: C19.L2 24.42,114.8 25.44,115.81 25.44,124.45 30.52,129.53 33.06,129.53 C19.E1
N$98
  Bottom 0.254: 101.64,185.41 91.98,185.41 90.97,184.39 B14.J2 | 101.64,185.41 102.65,184.39 B13.J2 | 117.38,185.41 118.4,184.39 B12.J2 | 101.64,185.41 117.38,185.41 | 130.08,185.41 131.1,184.39 B11.J2 | 117.38,185.41 130.08,185.41 | 142.78,185.41 143.8,184.39 B10.J2 | 130.08,185.41 142.78,185.41 | 155.48,185.41 156.5,184.39 B09.J2 | 142.78,185.41 155.48,185.41 | 172.25,185.41 172.76,184.9 B08.J2 | 155.48,185.41 172.25,185.41 | 184.95,185.41 185.46,184.9 B07.J2 | 172.25,185.41 184.95,185.41 | 197.65,185.41 198.16,184.9 B06.J2 | 184.95,185.41 197.65,185.41 | 210.35,185.41 210.86,184.9 B05.J2 | 197.65,185.41 210.35,185.41 | 225.59,185.41 226.6,184.39 B04.J2 | 210.35,185.41 225.59,185.41 | 238.29,185.41 239.3,184.39 B03.J2 | 225.59,185.41 238.29,185.41 | 250.99,185.41 252,184.39 B02.J2 | 238.29,185.41 250.99,185.41 | 250.99,185.41 263.69,185.41 264.7,184.39 B01.J2
N$99  (via drill 0.61)
  Top 0.254: v37.12,124.45 37.12,121.91 36.61,121.4 C18.J2
  Bottom 0.254: v37.12,124.45 42.2,129.53 45.76,129.53 C18.E1
N$100  (via drill 0.61)
  Top 0.254: v15.78,96.51 15.78,89.9 v12.23,86.35
  Bottom 0.254: v15.78,96.51 22.39,103.11 27.98,103.11 37.63,112.76 57.44,112.76 58.46,111.75 C17.M1 | v12.23,86.35 11.21,85.33 3.59,85.33 3.08,84.82 3.08,25.9 7.66,25.9 19.34,14.21 85.38,14.21 85.89,14.72 217.46,14.72 220,17.26 272.32,17.26 278.42,23.36 278.42,261.61 106.72,261.61 104.18,259.07 93.51,259.07 87.41,252.97 87.41,251.45 A15.K1
N$101  (via drill 0.61)
  Top 0.254: v47.28,90.92 47.28,99.56 48.8,101.08 C17.R2 | v168.69,5.58 223.05,59.93 223.05,276.34 v207.81,291.58 | v98.59,291.58 76.24,269.23 76.24,242.81 77.25,241.8 A15.N2
  Bottom 0.254: v47.28,90.92 43.72,87.36 3.59,87.36 3.08,87.87 2.07,87.87 1.56,87.36 1.56,5.58 v168.69,5.58 | v207.81,291.58 v98.59,291.58
N$103
  Top 0.254: D18.D2 36.1,64 35.6,64.5 35.6,66.54 34.07,68.06 32.04,68.06 32.04,67.04 31.02,66.03 29.5,66.03 29.5,69.58 D19.B1
N$104  (via drill 0.61)
  Top 0.254: v102.14,78.73 102.14,71.11 101.64,70.6 101.64,68.06 108.24,61.46 108.24,24.37 111.8,20.82 120.94,20.82 120.94,36.06 v140.75,55.87 | v176.31,56.38 174.28,58.41 174.28,76.19 172.25,78.22 172.25,85.84 174.28,87.87 174.28,189.47 190.54,205.73 190.54,221.48 183.93,228.08 183.93,247.38 v172.76,258.56 | v129.07,259.07 v119.42,268.72
  Bottom 0.254: v102.14,78.73 86.9,78.73 78.78,86.86 64.55,86.86 59.47,91.94 C17.U1 | v140.75,55.87 174.28,55.87 174.79,56.38 v176.31,56.38 | v172.76,258.56 172.25,259.07 v129.07,259.07 | v119.42,268.72 118.91,268.21 111.8,268.21 111.29,268.72 107.73,268.72 107.22,268.21 99.1,268.21 98.59,268.72 95.03,268.72 94.52,268.21 88.94,268.21 86.9,266.18 85.89,266.18 81.82,262.12 77.25,262.12 70.14,255 70.14,251.45 73.19,251.45 78.78,257.04 80.3,257.04 A15.H2
N$105
  Bottom 0.254: 104.68,182.36 95.03,182.36 94.02,181.34 B14.K2 | 104.68,182.36 105.7,181.34 B13.K2 | 104.68,182.36 120.94,182.36 121.96,181.34 B12.K2 122.97,180.84 123.48,180.84 125,179.31 129.07,179.31 129.58,179.82 134.15,179.82 134.66,180.33 B11.K2 135.67,180.84 137.2,179.31 141.77,179.31 142.78,180.33 147.36,180.33 B10.K2 148.37,180.84 149.9,179.31 154.47,179.31 154.98,179.82 159.55,179.82 160.06,180.33 B09.K2 161.07,180.84 162.09,179.82 166.15,179.82 166.66,179.31 167.17,179.31 168.18,180.33 175.8,180.33 B08.K2 176.82,181.34 177.84,182.36 187.49,182.36 | 187.49,182.36 188.5,181.34 B07.K2 | 200.19,182.36 201.2,181.34 B06.K2 | 187.49,182.36 200.19,182.36 | 212.89,182.36 213.9,181.34 B05.K2 | 200.19,182.36 212.89,182.36 | 228.64,182.36 229.65,181.34 B04.K2 | 212.89,182.36 228.64,182.36 | 241.34,182.36 242.35,181.34 B03.K2 | 228.64,182.36 241.34,182.36 | 254.04,182.36 255.05,181.34 B02.K2 | 241.34,182.36 254.04,182.36 | 254.04,182.36 266.74,182.36 267.75,181.34 B01.K2
N$107  (via drill 0.61)
  Top 0.254: v129.07,172.71 131.61,175.25 131.61,177.28 B11.L2 | v161.07,178.8 161.07,178.3 157.52,178.3 B09.L2
  Bottom 0.254: B09.L2 154.47,177.79 152.94,176.26 145.83,176.26 144.82,177.28 B10.L2 143.8,177.79 142.78,176.77 139.23,176.77 138.72,176.26 134.66,176.26 133.64,177.28 132.12,177.28 B11.L2 129.07,177.79 127.54,176.26 120.43,176.26 119.42,177.28 B12.L2 | B13.L2 102.65,178.3 102.14,178.3 101.13,179.31 91.98,179.31 90.97,178.3 B14.L2 90.97,177.28 90.97,172.71 v129.07,172.71 | 200.7,179.31 199.17,177.79 B06.L2 | 200.7,179.31 209.84,179.31 210.86,178.3 B05.L2 211.87,177.79 212.89,178.8 216.44,178.8 216.95,179.31 221.02,179.31 222.03,178.3 226.6,178.3 B04.L2 227.62,178.3 228.13,178.8 232.19,178.8 232.7,179.31 237.78,179.31 238.8,178.3 239.3,178.3 B03.L2 240.32,178.3 240.83,178.8 244.89,178.8 245.4,179.31 254.04,179.31 | 200.7,179.31 191.55,179.31 191.04,178.8 187.49,178.8 186.47,177.79 B07.L2 185.46,178.3 183.93,178.3 182.92,179.31 178.85,179.31 178.34,178.8 174.79,178.8 173.77,177.79 B08.L2 172.76,178.3 166.66,178.3 165.64,179.31 161.58,179.31 v161.07,178.8 | 254.04,179.31 253.02,178.3 B02.L2 | 254.04,179.31 263.69,179.31 264.7,178.3 B01.L2
N$108  (via drill 0.61)
  Top 0.254: v46.77,19.29 35.09,30.98 35.09,45.71 37.63,45.71 38.14,45.2 38.14,40.63 38.64,40.12 38.64,39.61 40.17,39.61 41.18,40.63 41.18,52.31 40.17,53.33 D18.H2 | v110.78,23.86 117.89,30.98 117.89,66.03 120.43,68.57 120.43,76.19 117.38,79.24 117.38,135.62 120.43,138.67 120.43,142.23 116.37,146.29 116.37,196.08 v113.83,198.62 | v103.67,198.62 101.64,200.65 101.64,208.78 v99.6,210.81 | v84.36,210.3 83.35,209.28 v83.35,206.24 | v72.68,201.66 69.63,201.66 69.63,199.12 v64.55,194.04
  Bottom 0.254: v46.77,19.29 47.79,20.31 89.44,20.31 93,23.86 104.68,23.86 105.19,24.37 108.24,24.37 108.75,23.86 v110.78,23.86 | v103.67,198.62 v113.83,198.62 | v99.6,210.81 99.1,210.3 v84.36,210.3 | v83.35,206.24 78.78,201.66 v72.68,201.66 | v64.55,194.04 62.52,192.01 57.95,192.01 56.93,191 55.92,191 B17.F1
N$109  (via drill 0.61)
  Top 0.254: v65.57,75.68 66.58,74.66 v66.58,65.01 | v62.01,53.33 62.01,15.74 v64.55,13.2 | v169.2,13.2 172.25,16.24 172.25,17.26 171.74,17.77 171.74,193.03 174.28,195.57 174.28,209.79 171.74,212.33 171.74,269.23 174.28,271.77 v174.28,278.88 | v102.14,280.91 92.49,271.26 92.49,236.21 91.98,235.7 91.98,234.18 91.48,233.67 86.4,233.67 v86.4,234.18
  Bottom 0.254: v65.57,75.68 64.04,75.68 64.04,80.25 55.92,88.38 C17.V1 | v66.58,65.01 66.58,58.41 64.04,58.41 62.01,56.38 v62.01,53.33 | v64.55,13.2 65.06,13.7 85.89,13.7 86.4,14.21 96.05,14.21 97.57,12.69 98.59,12.69 99.6,13.7 168.69,13.7 v169.2,13.2 | v174.28,278.88 172.25,280.91 v102.14,280.91 | v86.4,234.18 85.89,234.68 84.87,234.68 A15.R1
N$111
  Top 0.254: D18.J2 36.1,51.3 32.04,51.3 32.04,65.01 33.06,66.03 D19.C1
N$112  (via drill 0.61)
  Top 0.254: v5.12,65.01 4.1,66.03 4.1,87.36 3.59,87.87 3.59,142.23 5.12,143.75 5.12,144.77 4.61,145.28 4.61,148.83 v5.12,149.34 | v47.28,149.85 47.28,152.9 48.8,154.42 48.8,157.98 B17.T2
  Bottom 0.254: v5.12,65.01 22.39,65.01 23.4,64 D19.D2 | v5.12,149.34 5.62,149.85 v47.28,149.85
N$113  (via drill 0.61)
  Top 0.254: v20.86,86.35 18.83,88.38 18.83,98.03 9.69,107.18 9.69,110.73 16.29,117.34 16.29,121.91 20.36,125.97 v20.86,125.97 | v25.44,130.54 28.48,133.59 v28.48,140.2 | v39.15,140.2 41.18,142.23 41.18,161.53 44.23,164.58 44.23,181.34 47.28,184.39 47.28,184.9 v49.82,187.44 | v66.58,187.44 67.09,187.95 67.09,188.46 v69.12,190.49 | v72.68,192.01 74.2,190.49 74.2,187.95 B16.H1
  Bottom 0.254: v20.86,86.35 21.88,86.35 21.88,78.73 18.32,75.17 4.1,75.17 4.1,62.47 5.62,60.95 9.69,60.95 21.37,49.26 23.91,49.26 23.91,45.2 D19.L2 | v25.44,130.54 v20.86,125.97 | v28.48,140.2 29.5,141.21 38.14,141.21 v39.15,140.2 | v49.82,187.44 51.34,188.96 61.5,188.96 63.03,187.44 v66.58,187.44 | v69.12,190.49 70.65,192.01 v72.68,192.01
N$115
  Bottom 0.254: B01.M2 267.75,174.74 266.74,175.76 263.18,175.76 262.67,176.26 257.08,176.26 256.07,175.25 B02.M2 255.05,174.74 252.51,174.74 250.99,176.26 244.38,176.26 243.37,175.25 B03.M2 242.35,174.74 241.34,175.76 237.78,175.76 237.27,176.26 231.68,176.26 230.67,175.25 B04.M2 229.65,174.74 226.1,174.74 224.57,176.26 216.44,176.26 214.92,174.74 B05.M2 213.9,175.25 210.35,175.25 209.33,176.26 203.74,176.26 202.22,174.74 B06.M2 201.2,175.25 197.65,175.25 196.63,176.26 191.04,176.26 189.52,174.74 B07.M2 188.5,175.25 188,175.76 183.93,175.76 183.42,176.26 178.85,176.26 177.33,174.74 176.82,174.74 B08.M2 175.8,175.25 175.3,175.76 167.68,175.76 167.17,176.26 159.04,176.26 | 159.04,176.26 153.96,176.26 153.45,175.76 149.39,175.76 148.37,174.74 B10.M2 147.36,175.25 146.85,175.76 142.28,175.76 141.77,176.26 139.74,176.26 138.21,174.74 135.67,174.74 B11.M2 134.66,175.25 133.64,176.26 128.56,176.26 128.05,175.76 123.99,175.76 122.97,174.74 B12.M2 121.96,175.25 120.43,175.25 119.42,176.26 112.3,176.26 111.8,175.76 107.22,175.76 106.72,175.25 B13.M2 105.7,174.74 103.16,174.74 101.64,176.26 95.03,176.26 94.02,175.25 B14.M2 | 159.04,176.26 160.06,175.25 B09.M2
N$121
  Bottom 0.254: 104.68,169.66 95.03,169.66 94.02,168.64 B14.P2 | 104.68,169.66 105.7,168.64 B13.P2 | 104.68,169.66 120.94,169.66 121.96,168.64 B12.P2 122.97,168.14 124.5,166.61 129.07,166.61 129.58,167.12 134.15,167.12 134.66,167.63 B11.P2 135.67,168.14 136.69,167.12 140.75,167.12 141.26,166.61 142.78,166.61 143.8,167.63 147.36,167.63 B10.P2 148.37,168.14 149.9,166.61 155.48,166.61 156.5,167.63 160.06,167.63 B09.P2 161.07,168.14 162.6,166.61 174.28,166.61 175.3,167.63 175.8,167.63 B08.P2 176.82,168.64 177.33,169.15 181.39,169.15 181.9,169.66 187.49,169.66 | 187.49,169.66 188.5,168.64 B07.P2 | 200.19,169.66 201.2,168.64 B06.P2 | 187.49,169.66 200.19,169.66 | 212.89,169.66 213.9,168.64 B05.P2 | 200.19,169.66 212.89,169.66 | 228.64,169.66 229.65,168.64 B04.P2 | 212.89,169.66 228.64,169.66 | 241.34,169.66 242.35,168.64 B03.P2 | 228.64,169.66 241.34,169.66 | 254.04,169.66 255.05,168.64 B02.P2 | 241.34,169.66 254.04,169.66 | 254.04,169.66 266.74,169.66 267.75,168.64 B01.P2
N$122
  Top 0.254: C16.V1 71.16,89.4 70.14,90.41 70.14,100.06 71.16,101.08 C16.R1 | C16.B1 71.16,139.18 71.16,134.1 C16.D1 71.66,132.58 71.66,129.02 72.68,128 72.68,122.42 71.66,121.4 C16.J1 | C16.C1 75.22,136.13 75.73,135.62 75.73,131.05 76.24,130.54 76.24,125.97 74.71,124.45 C16.H1 74.2,123.43 74.2,117.84 C16.K1 74.2,116.83 72.68,115.3 72.68,109.72 71.66,108.7 C16.N1
  Bottom 0.254: C16.N1 71.66,107.18 73.7,105.14 74.2,105.14 C16.P1 74.2,104.13 72.17,102.1 71.66,102.1 C16.R1 | C16.J1 71.66,119.88 73.7,117.84 74.2,117.84 C16.K1
N$123
  Bottom 0.254: B14.R1 97.57,165.09 98.59,164.07 102.14,164.07 102.65,163.56 106.72,163.56 107.73,164.58 109.26,164.58 B13.R1 110.27,165.09 110.78,165.6 117.38,165.6 118.4,166.61 123.48,166.61 124.5,165.6 125,165.6 B12.R1 126.02,165.6 126.53,166.1 130.59,166.1 131.1,166.61 136.69,166.61 137.7,165.6 B11.R1 138.72,165.6 139.23,166.1 143.29,166.1 143.8,166.61 148.88,166.61 149.9,165.6 150.4,165.6 B10.R1 151.42,165.6 151.93,166.1 155.99,166.1 156.5,166.61 161.58,166.61 162.6,165.6 163.1,165.6 B09.R1 164.12,164.58 167.17,164.58 168.18,163.56 177.84,163.56 178.85,164.58 B08.R1 179.87,164.58 183.42,164.58 184.44,163.56 186.47,163.56 186.98,164.07 191.04,164.07 191.55,164.58 B07.R1 192.57,164.58 193.08,164.07 197.14,164.07 197.65,163.56 202.73,163.56 203.74,164.58 204.25,164.58 B06.R1 205.27,164.58 209.33,164.58 210.35,163.56 211.87,163.56 212.38,164.07 216.44,164.07 216.95,164.58 B05.R1 217.97,164.58 225.08,164.58 226.1,163.56 227.62,163.56 228.13,164.07 231.68,164.07 232.7,165.09 B04.R1 233.72,164.58 234.22,164.07 238.8,164.07 239.3,163.56 243.37,163.56 244.89,165.09 B03.R1 246.42,164.58 246.92,164.07 251.5,164.07 252,163.56 256.07,163.56 257.59,165.09 B02.R1 259.12,164.58 259.62,164.07 264.2,164.07 264.7,163.56 269.28,163.56 270.8,165.09 B01.R1
N$126  (via drill 0.61)
  Top 0.254: v129.07,160.01 131.61,162.55 131.61,164.58 B11.R2 | v182.92,160.01 185.46,162.55 185.46,164.58 B07.R2