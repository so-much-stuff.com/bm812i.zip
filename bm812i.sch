# EAGLE board bm812i (EAGLE 4.11), part 2 of 5
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
D03MA0L  (via drill 0.61) (continued)
  Bottom 0.254: v86.9,265.16 94.02,265.16 95.03,266.18 96.56,266.18 A14.D1 101.13,266.69 102.65,265.16 108.24,265.16 109.26,266.18 A13.D1 110.27,266.69 111.29,265.67 117.89,265.67 118.4,265.16 123.48,265.16 124.5,266.18 125,266.18 A12.D1 126.02,266.18 126.53,265.67 130.59,265.67 131.1,265.16 136.18,265.16 137.2,266.18 137.7,266.18 A11.D1 138.72,266.18 139.23,265.67 143.29,265.67 143.8,265.16 152.44,265.16 | A01.D1 270.8,266.69 269.28,265.16 264.7,265.16 264.2,265.67 259.62,265.67 259.12,266.18 A02.D1 257.59,266.69 256.07,265.16 252,265.16 251.5,265.67 246.92,265.67 246.42,266.18 A03.D1 244.89,266.69 243.37,265.16 239.3,265.16 238.8,265.67 234.22,265.67 233.72,266.18 A04.D1 232.7,266.69 231.68,265.67 228.13,265.67 227.62,265.16 226.1,265.16 225.08,266.18 217.97,266.18 A05.D1 216.95,266.18 216.44,266.18 215.43,265.16 210.35,265.16 209.84,265.67 205.78,265.67 205.27,266.18 A06.D1 204.25,266.18 203.74,266.18 202.73,265.16 197.65,265.16 197.14,265.67 193.08,265.67 192.57,266.18 A07.D1 191.55,266.18 191.04,266.18 190.03,265.16 184.95,265.16 184.44,265.67 180.38,265.67 179.87,266.18 A08.D1 178.85,266.18 178.34,266.18 177.33,265.16 172.25,265.16 171.74,265.67 164.63,265.67 164.12,266.18 A09.D1 163.1,266.18 162.6,266.18 161.58,265.16 152.44,265.16 | 152.44,265.16 151.42,266.18 A10.D1
D03MA1L  (via drill 0.61)
  Top 0.254: v79.79,171.69 79.79,169.15 80.3,168.64 B15.P2 | v63.54,175.25 63.54,197.6 75.73,209.79 75.73,221.98 73.19,224.52 73.19,251.45 72.68,251.96 v72.68,252.46
  Bottom 0.254: v79.79,171.69 78.27,173.22 65.57,173.22 v63.54,175.25 | v72.68,252.46 81.82,261.61 98.08,261.61 98.59,262.12 | 98.59,262.12 99.6,263.13 A14.E1 | 111.29,262.12 112.3,263.13 A13.E1 | 111.29,262.12 98.59,262.12 | 127.04,262.12 128.05,263.13 A12.E1 | 127.04,262.12 111.29,262.12 | 139.74,262.12 140.75,263.13 A11.E1 | 139.74,262.12 127.04,262.12 | 152.44,262.12 153.45,263.13 A10.E1 | 152.44,262.12 139.74,262.12 | 165.14,262.12 166.15,263.13 A09.E1 | 165.14,262.12 152.44,262.12 | 180.88,262.12 181.9,263.13 A08.E1 | 180.88,262.12 165.14,262.12 | 193.58,262.12 194.6,263.13 A07.E1 | 193.58,262.12 180.88,262.12 | 206.28,262.12 207.3,263.13 A06.E1 | 206.28,262.12 193.58,262.12 | 218.98,262.12 220,263.13 A05.E1 | 218.98,262.12 206.28,262.12 | 235.24,262.12 236.26,263.13 A04.E1 | 235.24,262.12 218.98,262.12 | 247.94,262.12 248.96,263.13 A03.E1 | 247.94,262.12 235.24,262.12 | 260.64,262.12 261.66,263.13 A02.E1 | 247.94,262.12 260.64,262.12 | 260.64,262.12 273.34,262.12 274.36,263.13 A01.E1
D03MA2L  (via drill 0.61)
  Top 0.254: v97.06,150.36 98.08,151.37 98.08,255 99.6,256.53 A14.H1 | A01.H1 274.36,257.54 269.78,257.54 269.78,258.05 269.28,258.56 262.67,258.56 262.67,257.54 A02.H1 | v175.3,258.56 181.9,258.56 181.9,257.54 A08.H1 | v120.43,257.54 121.45,258.56 128.05,258.56 128.05,257.54 A12.H1
  Bottom 0.254: v97.06,150.36 79.79,150.36 78.27,151.88 B15.V2 | A14.H1 100.62,257.04 101.13,257.04 102.65,255.51 111.29,255.51 112.3,256.53 A13.H1 113.32,257.54 v120.43,257.54 | 139.74,258.56 130.08,258.56 129.07,257.54 A12.H1 | 139.74,258.56 140.75,257.54 A11.H1 | 152.44,258.56 153.45,257.54 A10.H1 | 152.44,258.56 139.74,258.56 | 152.44,258.56 165.14,258.56 166.15,257.54 A09.H1 167.17,257.54 174.28,257.54 v175.3,258.56 | A08.H1 182.92,256.53 183.93,255.51 190.54,255.51 192.06,257.04 194.6,257.04 A07.H1 195.62,256.53 196.63,255.51 203.24,255.51 204.76,257.04 207.3,257.04 A06.H1 208.32,256.53 209.33,255.51 215.94,255.51 217.46,257.04 220,257.04 A05.H1 221.02,256.53 225.59,256.53 226.6,255.51 235.24,255.51 235.75,256.02 | 235.75,256.02 236.26,256.53 A04.H1 | 235.75,256.02 242.35,256.02 242.86,255.51 247.94,255.51 248.96,256.53 A03.H1 249.97,257.04 253.02,257.04 254.54,255.51 260.64,255.51 261.66,256.53 A02.H1
D03MA3L  (via drill 0.61)
  Top 0.254: v95.03,132.58 95.54,133.08 95.54,143.75 v98.08,146.29 | v109.76,147.31 111.29,147.31 111.29,147.82 v111.8,148.32 | v203.74,148.83 209.84,154.93 209.84,237.73 218.98,246.88 218.98,252.46 217.97,253.48 A05.J1
  Bottom 0.254: A14.J1 97.57,253.99 98.59,252.97 102.14,252.97 102.65,252.46 106.72,252.46 107.73,253.48 109.26,253.48 A13.J1 110.27,253.99 111.29,255 117.89,255 118.4,255.51 123.48,255.51 124.5,254.5 125,254.5 A12.J1 126.02,254.5 126.53,255 130.59,255 131.1,255.51 136.18,255.51 137.2,254.5 137.7,254.5 A11.J1 138.72,254.5 141.77,254.5 142.78,255.51 145.32,255.51 145.83,255 149.9,255 150.4,254.5 A10.J1 151.42,254.5 154.47,254.5 155.48,255.51 158.02,255.51 159.55,253.99 A09.J1 164.12,253.48 164.63,252.97 171.74,252.97 172.25,252.46 177.33,252.46 178.34,253.48 178.85,253.48 A08.J1 179.87,253.48 180.38,252.97 184.44,252.97 184.95,252.46 190.03,252.46 191.04,253.48 191.55,253.48 A07.J1 192.57,253.48 193.08,252.97 197.14,252.97 197.65,252.46 202.73,252.46 203.74,253.48 204.25,253.48 A06.J1 205.27,253.48 205.78,252.97 209.84,252.97 210.35,252.46 215.43,252.46 216.44,253.48 216.95,253.48 A05.J1 217.97,253.48 225.08,253.48 226.1,252.46 227.62,252.46 228.13,252.97 231.68,252.97 232.7,253.99 A04.J1 233.72,254.5 234.22,255 238.8,255 239.3,255.51 241.84,255.51 243.37,253.99 A03.J1 246.42,254.5 246.92,255 251.5,255 252,255.51 253.53,255.51 255.05,253.99 A02.J1 259.12,254.5 259.62,255 264.2,255 264.7,255.51 268.77,255.51 270.29,253.99 A01.J1 | v95.03,132.58 94.02,132.58 92.49,131.05 88.43,131.05 87.92,130.54 C15.E1 | v98.08,146.29 99.1,147.31 v109.76,147.31 | v111.8,148.32 112.81,147.31 134.66,147.31 136.18,148.83 v203.74,148.83
D03MA4L  (via drill 0.61)
  Top 0.254: v89.95,112.26 88.94,111.24 v88.94,94.48 | v105.7,93.97 108.24,96.51 v108.24,146.29 | v136.18,146.29 136.69,146.8 136.69,194.55 138.21,196.08 B11.D1
  Bottom 0.254: 108.75,195.57 98.59,195.57 97.57,196.58 B14.D1 | 108.75,195.57 109.26,196.08 B13.D1 | 108.75,195.57 123.99,195.57 125,196.58 B12.D1 126.02,196.58 127.04,195.57 139.74,195.57 | v89.95,112.26 86.9,115.3 85.89,115.3 84.87,114.29 C15.L1 | v88.94,94.48 89.44,93.97 v105.7,93.97 | v136.18,146.29 v108.24,146.29 | 149.39,195.57 150.4,196.58 B10.D1 | 139.74,195.57 149.39,195.57 | 139.74,195.57 138.72,196.58 B11.D1 | 162.09,195.57 163.1,196.58 B09.D1 | 149.39,195.57 162.09,195.57 | 177.84,195.57 178.85,196.58 B08.D1 | 162.09,195.57 177.84,195.57 | 190.54,195.57 191.55,196.58 B07.D1 | 177.84,195.57 190.54,195.57 | 203.24,195.57 204.25,196.58 B06.D1 | 190.54,195.57 203.24,195.57 | 215.94,195.57 216.95,196.58 B05.D1 | 203.24,195.57 215.94,195.57 | 231.68,195.57 232.7,196.58 B04.D1 | 215.94,195.57 231.68,195.57 | 244.38,195.57 245.4,196.58 B03.D1 | 231.68,195.57 244.38,195.57 | 257.08,195.57 258.1,196.58 B02.D1 | 244.38,195.57 257.08,195.57 | 257.08,195.57 269.78,195.57 270.8,196.58 B01.D1
D03MA5L  (via drill 0.61)
  Top 0.254: v115.35,106.67 115.35,190.49 112.81,193.03 B13.E1 113.32,194.04 115.35,194.04 v115.35,194.55 | v168.69,191.5 167.17,193.03 B09.E1
  Bottom 0.254: v115.35,106.67 93.51,106.67 89.95,103.11 87.41,103.11 87.41,99.05 C15.S1 | B14.E1 100.62,193.54 102.14,192.01 110.27,192.01 111.29,193.03 112.3,193.03 B13.E1 | 130.08,195.06 129.07,194.04 B12.E1 | 130.08,195.06 139.74,195.06 | 139.74,195.06 140.75,194.04 B11.E1 | 152.44,195.06 153.45,194.04 B10.E1 | 139.74,195.06 152.44,195.06 | 152.44,195.06 165.14,195.06 166.15,194.04 B09.E1 | 183.93,192.01 182.92,193.03 B08.E1 | 183.93,192.01 193.08,192.01 | 193.08,192.01 194.6,193.54 B07.E1 | 205.78,192.01 207.3,193.54 B06.E1 | 193.08,192.01 205.78,192.01 | 218.48,192.01 220,193.54 B05.E1 | 205.78,192.01 218.48,192.01 | 235.24,192.01 236.26,193.03 B04.E1 | 218.48,192.01 235.24,192.01 | 247.94,192.01 248.96,193.03 B03.E1 | 235.24,192.01 247.94,192.01 | 260.64,192.01 261.66,193.03 B02.E1 | 247.94,192.01 260.64,192.01 | 260.64,192.01 273.34,192.01 274.36,193.03 B01.E1 | v168.69,191.5 169.2,192.01 183.93,192.01 | v115.35,194.55 115.86,195.06 130.08,195.06
D03MA6L  (via drill 0.61)
  Top 0.254: v100.62,128.51 101.64,129.53 101.64,185.92 100.62,186.93 B14.H1
  Bottom 0.254: v100.62,128.51 89.95,128.51 83.86,122.42 79.79,122.42 78.27,120.89 C15.J2 | 111.29,185.92 112.3,186.93 B13.H1 | 111.29,185.92 101.64,185.92 100.62,186.93 B14.H1 | 127.04,185.92 128.05,186.93 B12.H1 | 111.29,185.92 127.04,185.92 | 139.74,185.92 140.75,186.93 B11.H1 | 127.04,185.92 139.74,185.92 | 152.44,185.92 153.45,186.93 B10.H1 | 139.74,185.92 152.44,185.92 | 165.14,185.92 166.15,186.93 B09.H1 | 152.44,185.92 165.14,185.92 | 180.88,185.92 181.9,186.93 B08.H1 | 165.14,185.92 180.88,185.92 | 193.58,185.92 194.6,186.93 B07.H1 | 180.88,185.92 193.58,185.92 | 206.28,185.92 207.3,186.93 B06.H1 | 193.58,185.92 206.28,185.92 | 218.98,185.92 220,186.93 B05.H1 | 206.28,185.92 218.98,185.92 | 235.24,185.92 236.26,186.93 B04.H1 | 218.98,185.92 235.24,185.92 | 247.94,185.92 248.96,186.93 B03.H1 | 235.24,185.92 247.94,185.92 | 260.64,185.92 261.66,186.93 B02.H1 | 247.94,185.92 260.64,185.92 | 260.64,185.92 273.34,185.92 274.36,186.93 B01.H1
D03MA7L  (via drill 0.61)
  Top 0.254: v86.4,114.29 85.89,114.8 85.89,128.51 85.38,129.02 85.38,156.45 85.89,156.96 85.89,163.56 88.94,166.61 88.94,169.66 87.92,170.68 v87.92,172.71
  Bottom 0.254: v86.4,114.29 81.82,109.72 81.32,109.72 81.32,105.14 C15.P2 | v87.92,172.71 88.94,173.72 88.94,182.87 96.05,182.87 | 96.05,182.87 96.56,183.38 B14.J1 | 108.75,182.87 109.26,183.38 B13.J1 | 96.05,182.87 108.75,182.87 | 123.99,182.87 125,183.88 B12.J1 | 108.75,182.87 123.99,182.87 | 136.69,182.87 137.7,183.88 B11.J1 | 123.99,182.87 136.69,182.87 | 149.39,182.87 150.4,183.88 B10.J1 | 136.69,182.87 149.39,182.87 | 162.09,182.87 163.1,183.88 B09.J1 | 149.39,182.87 162.09,182.87 | 177.84,182.87 178.85,183.88 B08.J1 | 162.09,182.87 177.84,182.87 | 190.54,182.87 191.55,183.88 B07.J1 | 177.84,182.87 190.54,182.87 | 203.24,182.87 204.25,183.88 B06.J1 | 190.54,182.87 203.24,182.87 | 215.94,182.87 216.95,183.88 B05.J1 | 203.24,182.87 215.94,182.87 | 231.68,182.87 232.7,183.88 B04.J1 | 215.94,182.87 231.68,182.87 | 244.38,182.87 245.4,183.88 B03.J1 | 231.68,182.87 244.38,182.87 | 257.08,182.87 258.1,183.88 B02.J1 | 244.38,182.87 257.08,182.87 | 257.08,182.87 269.78,182.87 270.8,183.88 B01.J1
D03MA8L  (via drill 0.61)
  Top 0.254: v93.51,79.74 95.54,77.71 95.54,65.01 96.56,64 D14.D1
  Bottom 0.254: D14.D1 97.57,63.49 98.59,62.47 102.14,62.47 102.65,61.96 106.72,61.96 107.73,62.98 109.26,62.98 D13.D1 110.27,63.49 111.29,62.47 117.89,62.47 118.4,61.96 123.48,61.96 124.5,62.98 125,62.98 D12.D1 126.02,62.98 126.53,62.47 130.59,62.47 131.1,61.96 136.18,61.96 137.2,62.98 137.7,62.98 D11.D1 138.72,62.98 139.23,62.47 143.29,62.47 143.8,61.96 148.88,61.96 149.9,62.98 150.4,62.98 D10.D1 151.42,62.98 151.93,62.47 155.99,62.47 156.5,61.96 161.58,61.96 162.6,62.98 163.1,62.98 D09.D1 164.12,62.98 164.63,62.47 171.74,62.47 172.25,61.96 177.33,61.96 178.34,62.98 178.85,62.98 D08.D1 179.87,62.98 180.38,62.47 184.44,62.47 184.95,61.96 190.03,61.96 191.04,62.98 191.55,62.98 D07.D1 192.57,62.98 193.08,62.47 197.14,62.47 197.65,61.96 202.73,61.96 203.74,62.98 204.25,62.98 D06.D1 205.27,62.98 205.78,62.47 209.84,62.47 210.35,61.96 215.43,61.96 216.44,62.98 216.95,62.98 D05.D1 217.97,62.98 221.52,62.98 222.54,61.96 227.62,61.96 228.13,62.47 231.68,62.47 232.7,63.49 D04.D1 233.72,62.98 234.22,62.47 238.8,62.47 239.3,61.96 243.37,61.96 244.89,63.49 D03.D1 246.42,62.98 246.92,62.47 251.5,62.47 252,61.96 256.07,61.96 257.59,63.49 D02.D1 259.12,62.98 259.62,62.47 264.2,62.47 264.7,61.96 269.28,61.96 270.8,63.49 D01.D1 | v93.51,79.74 86.9,79.74 78.27,88.38 C15.V2
D03MA9L  (via drill 0.61)
  Top 0.254: v73.19,120.89 73.19,128.51 74.2,129.53 C16.E1 | v94.02,119.37 101.64,111.75 101.64,97.52 101.13,97.02 101.13,92.95 101.64,92.44 101.64,90.41 101.13,89.9 101.13,74.16 101.64,73.65 101.64,71.62 101.13,71.11 101.13,67.55 101.64,67.04 101.64,62.47 100.11,60.95 D14.E1
  Bottom 0.254: D14.E1 100.62,59.93 101.64,58.92 111.29,58.92 112.3,59.93 D13.E1 113.32,59.93 114.34,58.92 130.08,58.92 | v73.19,120.89 74.71,119.37 v94.02,119.37 | 130.08,58.92 129.07,59.93 D12.E1 | 139.74,58.92 130.08,58.92 | 139.74,58.92 140.75,59.93 D11.E1 | 152.44,58.92 153.45,59.93 D10.E1 | 152.44,58.92 139.74,58.92 | 165.14,58.92 166.15,59.93 D09.E1 | 165.14,58.92 152.44,58.92 | 180.88,58.92 181.9,59.93 D08.E1 | 180.88,58.92 165.14,58.92 | 193.58,58.92 194.6,59.93 D07.E1 | 193.58,58.92 180.88,58.92 | 206.28,58.92 207.3,59.93 D06.E1 | 206.28,58.92 193.58,58.92 | 218.98,58.92 220,59.93 D05.E1 | 206.28,58.92 218.98,58.92 | 235.24,58.92 236.26,59.93 D04.E1 | 218.98,58.92 235.24,58.92 | 247.94,58.92 248.96,59.93 D03.E1 | 235.24,58.92 247.94,58.92 | 260.64,58.92 261.66,59.93 D02.E1 | 247.94,58.92 260.64,58.92 | 260.64,58.92 273.34,58.92 274.36,59.93 D01.E1
D03MA10L  (via drill 0.61)
  Top 0.254: v93.51,115.81 95.54,113.78 95.54,100.57 99.1,97.02 99.1,93.46 98.59,92.95 98.59,55.36 99.6,54.34 D14.H1 | v175.3,55.36 181.9,55.36 181.9,54.34 D08.H1 | v120.43,54.34 121.45,55.36 128.05,55.36 128.05,54.34 D12.H1
  Bottom 0.254: D14.H1 100.62,53.84 101.64,52.82 105.19,52.82 105.7,52.31 111.29,52.31 112.3,53.33 D13.H1 113.32,54.34 v120.43,54.34 | v93.51,115.81 77.25,115.81 76.74,115.3 73.19,115.3 72.17,114.29 C16.L1 | D12.H1 129.07,54.34 130.08,55.36 139.74,55.36 140.75,54.34 D11.H1 141.77,54.34 142.78,55.36 152.44,55.36 | 152.44,55.36 153.45,54.34 D10.H1 | 152.44,55.36 165.14,55.36 166.15,54.34 D09.H1 167.17,54.34 168.18,55.36 v175.3,55.36 | D08.H1 182.92,53.33 183.42,52.82 188,52.82 188.5,52.31 193.08,52.31 194.6,53.84 D07.H1 195.62,53.33 199.17,53.33 200.19,52.31 205.78,52.31 207.3,53.84 D06.H1 208.32,53.33 211.87,53.33 212.89,52.31 218.48,52.31 220,53.84 D05.H1 221.02,53.33 227.62,53.33 228.64,52.31 235.24,52.31 235.75,52.82 | 235.75,52.82 236.26,53.33 D04.H1 | 235.75,52.82 242.35,52.82 242.86,52.31 247.94,52.31 248.96,53.33 D03.H1 249.97,53.84 252.51,53.84 254.04,52.31 260.64,52.31 261.66,53.33 D02.H1 262.67,53.84 265.21,53.84 266.74,52.31 273.34,52.31 274.36,53.33 D01.H1
D03MA11L  (via drill 0.61)
  Top 0.254: v98.08,96.51 98.08,52.31 97.06,51.3 D14.J1
  Bottom 0.254: D14.J1 97.57,50.79 99.1,52.31 104.68,52.31 105.7,51.3 109.26,51.3 D13.J1 110.27,50.79 111.29,51.8 117.89,51.8 118.4,52.31 123.48,52.31 124.5,51.3 125,51.3 D12.J1 126.02,51.3 126.53,51.8 130.59,51.8 131.1,52.31 136.18,52.31 137.2,51.3 137.7,51.3 D11.J1 138.72,51.3 139.23,51.8 143.29,51.8 143.8,52.31 148.88,52.31 149.9,51.3 150.4,51.3 D10.J1 151.42,51.3 151.93,51.8 155.99,51.8 156.5,52.31 161.58,52.31 162.6,51.3 163.1,51.3 D09.J1 164.12,51.3 164.63,51.8 171.74,51.8 172.25,52.31 180.88,52.31 | v98.08,96.51 80.81,96.51 79.28,98.03 75.22,98.03 C16.S1 | D01.J1 270.8,50.79 269.78,51.8 266.23,51.8 265.72,52.31 261.66,52.31 260.64,51.3 259.12,51.3 D02.J1 258.1,50.79 257.08,51.8 253.53,51.8 253.02,52.31 248.96,52.31 247.94,51.3 246.42,51.3 D03.J1 243.37,50.79 241.84,52.31 239.3,52.31 238.8,51.8 234.22,51.8 233.72,51.3 D04.J1 232.7,50.79 231.68,51.8 228.13,51.8 227.62,52.31 219.49,52.31 218.48,51.3 217.97,51.3 D05.J1 216.95,51.3 216.44,51.8 212.38,51.8 211.87,52.31 206.79,52.31 205.78,51.3 205.27,51.3 D06.J1 204.25,51.3 203.74,51.8 199.68,51.8 199.17,52.31 194.09,52.31 193.08,51.3 192.57,51.3 D07.J1 191.55,51.3 188.5,51.3 187.49,52.31 180.88,52.31 | 180.88,52.31 179.87,51.3 D08.J1
D03MCBMB0L
  Top 0.254: A19N.S2 27.47,232.14 28.99,233.67 28.99,236.21 31.53,236.21 31.53,207.76 32.55,206.74 B19.A1
D03MCBMB1L  (via drill 0.61)
  Top 0.254: v25.94,204.71 25.44,205.22 25.44,227.06 24.42,228.08 A19N.T2
  Bottom 0.254: v25.94,204.71 28.48,204.71 29.5,203.7 B19.B1
D03MCBMB2L  (via drill 0.61)
  Top 0.254: v26.45,221.98 28.99,219.44 28.99,210.81 28.48,210.3 28.48,192.01 29.5,191 B19.F1
  Bottom 0.254: v26.45,221.98 24.42,221.98 A19N.V2
D03MCBMB3L  (via drill 0.61)
  Top 0.254: v12.74,185.92 12.23,186.42 12.23,200.14 10.7,201.66 9.18,201.66 9.18,260.59 10.7,262.12 10.7,266.18 A20N.D2
  Bottom 0.254: v12.74,185.92 22.39,185.92 25.44,188.96 31.53,188.96 32.55,187.95 B19.H1
D03MCBMB4L  (via drill 0.61)
  Top 0.254: v11.72,205.22 9.69,207.25 9.69,229.6 12.74,232.65 12.74,262.12 13.75,263.13 A20N.E2 | v16.29,204.71 15.78,204.2 15.78,186.42 12.23,182.87 v12.23,174.23
  Bottom 0.254: v11.72,205.22 12.74,204.2 15.78,204.2 v16.29,204.71 | v12.23,174.23 13.24,173.22 31.53,173.22 32.55,174.23 B19.M1
D03MCBMB5L  (via drill 0.61)
  Top 0.254: v2.58,176.77 2.58,195.06 4.61,197.09 4.61,198.62 4.1,199.12 4.1,268.21 11.72,268.21 15.78,264.15 15.78,258.56 14.77,257.54 A20N.H2
  Bottom 0.254: v2.58,176.77 6.13,173.22 12.23,173.22 12.74,172.71 28.99,172.71 29.5,172.2 B19.N1
D03MCBMB6L  (via drill 0.61)
  Top 0.254: v21.88,247.89 21.88,202.68 22.39,202.17 22.39,198.62 23.4,197.6 B19.D2
  Bottom 0.254: v21.88,247.89 23.4,249.42 38.14,249.42 39.15,250.43 A18N.K2
D03MCBMB7L  (via drill 0.61)
  Top 0.254: v33.56,192.01 37.63,196.08 37.63,220.97 38.14,221.48 38.14,242.3 39.66,243.83 A18N.M2
  Bottom 0.254: v33.56,192.01 28.99,192.01 27.47,193.54 B19.E2
D03MCBMB8L  (via drill 0.61)
  Top 0.254: v43.22,182.36 44.23,183.38 44.23,236.21 42.71,237.73 40.17,237.73 A18N.P2
  Bottom 0.254: v43.22,182.36 28.48,182.36 27.47,181.34 B19.K2
D03MCBMB9L  (via drill 0.61)
  Top 0.254: v33.56,179.31 34.58,180.33 34.58,191.5 38.14,195.06 38.14,215.89 v38.64,216.4 | v33.56,218.94 33.56,223.51 35.09,225.03 v35.09,231.13
  Bottom 0.254: v33.56,179.31 24.93,179.31 23.91,178.3 B19.L2 | v38.64,216.4 36.1,218.94 v33.56,218.94 | v35.09,231.13 35.6,231.64 39.15,231.64 A18N.S2
D03MCBMB10L  (via drill 0.61)
  Top 0.254: v41.69,166.61 41.18,167.12 41.18,220.97 41.69,221.48 v41.69,226.05
  Bottom 0.254: v41.69,166.61 34.58,166.61 31.53,163.56 24.93,163.56 23.91,164.58 B19.R2 | v41.69,226.05 39.66,228.08 37.12,228.08 A18N.T2
D03MCBMB11L  (via drill 0.61)
  Top 0.254: v38.64,163.56 40.68,165.6 v40.68,221.98
  Bottom 0.254: v38.64,163.56 32.55,163.56 32.04,163.06 28.48,163.06 27.47,162.04 B19.S2 | v40.68,221.98 37.12,221.98 A18N.V2
D03MEMSTART  (via drill 0.61)
  Top 0.254: 54.39,28.94 56.93,28.94 56.93,36.56 | 54.39,28.94 52.87,28.94 D17.S2 | 56.93,36.56 55.92,37.58 D17.N1 | D18.F1 43.22,56.38 44.23,55.36 44.23,47.23 46.77,44.69 48.8,44.69 D17.L2 | 56.93,36.56 56.93,68.06 55.92,69.08 D17.B1 | v86.9,292.6 66.58,272.28 66.58,245.86 67.6,244.84 A16.M2 | v63.03,8.12 54.39,16.75 54.39,28.94
  Bottom 0.254: D17.L2 49.31,43.68 49.31,39.61 53.38,39.61 54.9,38.09 D17.N1 | v86.9,292.6 88.43,294.12 273.34,294.12 283.5,283.96 283.5,8.12 v63.03,8.12
D04MD0L  (via drill 0.61)
  Top 0.254: v27.47,198.11 27.98,198.62 v27.98,211.32 | v32.55,211.32 32.04,211.82 32.04,234.68 34.58,237.22 v34.58,241.29 | v85.89,88.38 85.89,72.12 86.4,71.62 86.4,67.55 86.9,67.04 D15.C1 | v118.91,92.44 130.08,103.62 v130.08,107.18
  Bottom 0.254: v27.47,198.11 28.99,198.11 29.5,197.6 B19.D1 | v32.55,211.32 v27.98,211.32 | v34.58,241.29 36.1,242.81 70.65,242.81 76.74,248.91 93,248.91 93.51,249.42 98.59,249.42 | 98.59,249.42 99.6,250.43 A14.K1 | 111.29,249.42 112.3,250.43 A13.K1 | 111.29,249.42 98.59,249.42 | 127.04,249.42 128.05,250.43 A12.K1 | 127.04,249.42 111.29,249.42 | 139.74,249.42 140.75,250.43 A11.K1 | 139.74,249.42 127.04,249.42 | 152.44,249.42 153.45,250.43 A10.K1 | 152.44,249.42 139.74,249.42 | 165.14,249.42 166.15,250.43 A09.K1 | 165.14,249.42 152.44,249.42 | 180.88,249.42 181.9,250.43 A08.K1 | 180.88,249.42 165.14,249.42 | 193.58,249.42 194.6,250.43 A07.K1 | 193.58,249.42 180.88,249.42 | 206.28,249.42 207.3,250.43 A06.K1 | 206.28,249.42 193.58,249.42 | 218.98,249.42 220,250.43 A05.K1 | 218.98,249.42 206.28,249.42 | 235.24,249.42 236.26,250.43 A04.K1 | 235.24,249.42 218.98,249.42 | 235.24,249.42 247.94,249.42 248.96,250.43 A03.K1 249.97,250.43 250.99,249.42 263.69,249.42 | v85.89,88.38 87.92,90.41 95.03,90.41 95.54,90.92 99.1,90.92 99.6,90.41 104.68,90.41 105.19,89.9 108.24,89.9 108.75,90.41 116.88,90.41 v118.91,92.44 | v130.08,107.18 130.08,109.21 274.86,109.21 275.88,110.22 275.88,249.42 | 275.88,249.42 275.88,250.43 275.37,250.43 A01.K1 | 263.69,249.42 262.67,250.43 A02.K1 | 263.69,249.42 275.88,249.42
D04MD1L  (via drill 0.61)
  Top 0.254: v34.58,222.49 34.58,199.63 34.07,199.12 34.07,194.55 33.56,194.04 B19.E1 | v87.92,223.51 95.03,230.62 95.03,245.35 96.56,246.88 A14.L1 | v118.91,65.52 120.94,67.55 120.94,74.16 121.96,75.17 134.15,75.17 134.15,82.79 143.29,91.94 143.29,144.77 v144.82,146.29 | v177.33,146.29 194.09,163.06 194.09,189.98 209.33,205.22 209.33,240.78 208.32,241.8 | 208.32,241.8 204.76,245.35 204.76,246.88 A06.L1 | 208.32,241.8 212.38,245.86 212.38,247.38 216.95,247.38 A05.L1
  Bottom 0.254: v34.58,222.49 35.6,223.51 v87.92,223.51 | 108.75,246.37 109.26,246.88 A13.L1 | 108.75,246.37 98.59,246.37 97.57,247.38 A14.L1 | 123.99,246.37 125,247.38 A12.L1 | 108.75,246.37 123.99,246.37 | 136.69,246.37 137.7,247.38 A11.L1 | 123.99,246.37 136.69,246.37 | 149.39,246.37 150.4,247.38 A10.L1 | 136.69,246.37 149.39,246.37 | 162.09,246.37 163.1,247.38 A09.L1 | 149.39,246.37 162.09,246.37 | 177.84,246.37 178.85,247.38 A08.L1 | 162.09,246.37 177.84,246.37 | 177.84,246.37 190.54,246.37 191.55,247.38 A07.L1 192.57,247.38 193.58,246.37 203.24,246.37 204.25,247.38 A06.L1 | 244.38,246.37 234.22,246.37 233.72,246.88 A04.L1 232.7,247.38 231.68,246.37 218.98,246.37 217.97,247.38 A05.L1 | 244.38,246.37 245.4,247.38 A03.L1 | 257.08,246.37 258.1,247.38 A02.L1 | 244.38,246.37 257.08,246.37 | 257.08,246.37 269.78,246.37 270.8,247.38 A01.L1 | v118.91,65.52 118.4,65.01 112.3,65.01 111.8,65.52 108.24,65.52 107.73,65.01 99.6,65.01 99.1,65.52 95.54,65.52 95.03,65.01 89.95,65.01 86.9,61.96 82.33,61.96 81.32,60.95 D15.E2 | v177.33,146.29 v144.82,146.29
D04MD2L  (via drill 0.61)
  Top 0.254: v119.92,245.35 119.92,244.84 113.32,244.84 A13.M1 | v174.79,245.35 175.3,245.86 181.9,245.86 181.9,244.84 A08.M1 | v91.48,52.31 91.98,52.82 91.98,165.6 v89.95,167.63 89.95,169.66 88.94,170.68 88.94,191.5 v89.44,192.01 | v99.1,192.01 98.59,192.52 98.59,242.81 99.6,243.83 A14.M1
  Bottom 0.254: A14.M1 100.62,244.34 101.64,243.32 105.19,243.32 105.7,242.81 107.73,242.81 108.75,243.83 112.3,243.83 A13.M1 | 130.08,245.86 129.07,244.84 A12.M1 | 130.08,245.86 139.74,245.86 | 139.74,245.86 140.75,244.84 A11.M1 | 152.44,245.86 153.45,244.84 A10.M1 | 139.74,245.86 152.44,245.86 | 152.44,245.86 165.14,245.86 166.15,244.84 A09.M1 167.17,244.84 167.68,245.35 v174.79,245.35 | v119.92,245.35 120.43,245.86 130.08,245.86 | 193.08,242.81 183.93,242.81 182.92,243.83 A08.M1 | 193.08,242.81 194.6,244.34 A07.M1 | 205.78,242.81 207.3,244.34 A06.M1 | 193.08,242.81 205.78,242.81 | 218.48,242.81 220,244.34 A05.M1 | 205.78,242.81 218.48,242.81 | 235.24,242.81 236.26,243.83 A04.M1 | 218.48,242.81 235.24,242.81 | 247.94,242.81 248.96,243.83 A03.M1 | 235.24,242.81 247.94,242.81 | 260.64,242.81 261.66,243.83 A02.M1 | 247.94,242.81 260.64,242.81 | 260.64,242.81 273.34,242.81 274.36,243.83 A01.M1 | v91.48,52.31 86.4,52.31 84.87,50.79 D15.J1 | v89.95,167.63 87.41,170.17 46.77,170.17 36.61,180.33 33.56,180.33 B19.K1 | v89.44,192.01 v99.1,192.01
D04MD3L  (via drill 0.61)
  Top 0.254: v28.48,48.76 28.48,62.98 25.44,66.03 25.44,76.19 22.39,79.24 22.39,122.42 31.53,131.56 31.53,141.72 28.48,144.77 28.48,176.26 29.5,177.28 B19.L1 | v79.79,43.68 80.3,43.17 80.3,41.64 D15.M2 | v101.13,210.81 101.13,219.44 101.64,219.95 101.64,232.14 100.11,233.67 100.11,237.73 A14.P1 | v78.27,209.79 77.25,208.78 v77.25,206.74 | v52.36,204.71 50.84,203.19 50.84,183.88 v46.26,179.31 | v39.66,179.31 38.64,178.3 v38.64,176.77
  Bottom 0.254: 111.29,236.72 105.7,236.72 105.19,237.22 101.13,237.22 100.62,237.73 A14.P1 | 111.29,236.72 112.3,237.73 A13.P1 | 127.04,236.72 128.05,237.73 A12.P1 | 111.29,236.72 127.04,236.72 | 139.74,236.72 140.75,237.73 A11.P1 | 127.04,236.72 139.74,236.72 | 152.44,236.72 153.45,237.73 A10.P1 | 139.74,236.72 152.44,236.72 | 165.14,236.72 166.15,237.73 A09.P1 | 152.44,236.72 165.14,236.72 | 180.88,236.72 181.9,237.73 A08.P1 | 165.14,236.72 180.88,236.72 | 193.58,236.72 194.6,237.73 A07.P1 | 180.88,236.72 193.58,236.72 | 206.28,236.72 207.3,237.73 A06.P1 | 193.58,236.72 206.28,236.72 | 218.98,236.72 220,237.73 A05.P1 | 206.28,236.72 218.98,236.72 | 235.24,236.72 236.26,237.73 A04.P1 | 218.98,236.72 235.24,236.72 | 247.94,236.72 248.96,237.73 A03.P1 | 235.24,236.72 247.94,236.72 | 260.64,236.72 261.66,237.73 A02.P1 | 247.94,236.72 260.64,236.72 | 260.64,236.72 273.34,236.72 274.36,237.73 A01.P1 | v28.48,48.76 31.02,46.22 36.1,46.22 39.15,49.26 48.3,49.26 54.39,43.17 79.28,43.17 v79.79,43.68 | v101.13,210.81 100.11,209.79 85.38,209.79 84.87,209.28 78.78,209.28 v78.27,209.79 | v77.25,206.74 75.22,204.71 v52.36,204.71 | v46.26,179.31 v39.66,179.31 | v38.64,176.77 38.14,176.26 31.53,176.26 30.52,177.28 B19.L1
D04MD4L  (via drill 0.61)
  Top 0.254: B03.K1 249.97,181.34 254.04,181.34 255.05,182.36 261.66,182.36 261.66,181.34 B02.K1 | B07.K1 195.62,181.34 200.19,181.34 200.19,181.85 200.7,182.36 207.3,182.36 207.3,181.34 B06.K1 | v168.69,179.31 168.69,180.33 167.17,180.33 B09.K1 | v112.81,58.41 115.35,60.95 115.35,105.14 114.34,106.16 114.34,109.72 114.84,110.22 114.84,178.3 112.81,180.33 B13.K1 | D15.P1 87.41,35.55 88.43,36.56 88.43,40.12 88.94,40.63 v88.94,57.9 88.94,87.87 v86.4,90.41 | v14.26,166.61 12.23,164.58 12.23,149.85 7.66,145.28 7.66,133.59 v7.15,133.08 | v123.48,179.31 123.48,180.84 128.05,180.84 B12.K1
  Bottom 0.254: B03.K1 248.96,180.33 245.4,180.33 244.38,179.31 238.8,179.31 237.27,180.84 B04.K1 236.26,180.33 235.75,179.82 231.18,179.82 230.67,179.31 222.03,179.31 221.02,180.33 B05.K1 220,180.84 217.46,180.84 215.94,179.31 213.9,179.31 213.4,179.82 208.82,179.82 208.32,180.33 B06.K1 | B02.K1 262.67,180.84 263.69,179.82 267.75,179.82 268.26,179.31 273.34,179.31 274.36,180.33 B01.K1 | 139.74,182.36 130.08,182.36 129.07,181.34 B12.K1 | 139.74,182.36 140.75,181.34 B11.K1 | 152.44,182.36 153.45,181.34 B10.K1 | 139.74,182.36 152.44,182.36 | 152.44,182.36 165.14,182.36 166.15,181.34 B09.K1 | B07.K1 194.6,180.84 192.06,180.84 190.54,179.31 183.93,179.31 182.92,180.33 B08.K1 181.9,180.84 179.36,180.84 177.84,179.31 v168.69,179.31 | v88.94,57.9 89.44,58.41 v112.81,58.41 | v14.26,166.61 23.91,166.61 25.44,165.09 B19.R1 | v7.15,133.08 7.15,93.97 76.74,93.97 80.3,90.41 v86.4,90.41 | B14.K1 100.62,180.84 102.14,179.31 110.78,179.31 111.8,180.33 112.3,180.33 B13.K1 113.32,180.84 119.42,180.84 120.94,179.31 v123.48,179.31
D04MD5L  (via drill 0.61)
  Top 0.254: v87.92,26.91 88.94,27.93 88.94,39.61 92.49,43.17 92.49,131.56 95.03,134.1 95.03,175.76 96.56,177.28 B14.L1 96.56,178.3 96.56,181.85 v91.98,186.42 | v37.63,185.41 v37.63,162.55
  Bottom 0.254: B01.L1 270.8,177.79 269.28,176.26 264.7,176.26 264.2,176.77 259.62,176.77 259.12,177.28 B02.L1 257.59,177.79 256.07,176.26 252,176.26 251.5,176.77 246.92,176.77 246.42,177.28 B03.L1 244.89,177.79 243.37,176.26 239.3,176.26 238.8,176.77 234.22,176.77 233.72,177.28 B04.L1 232.7,177.79 231.68,176.77 228.13,176.77 227.62,176.26 225.59,176.26 224.57,177.28 217.97,177.28 B05.L1 216.95,177.28 216.44,176.77 212.38,176.77 211.87,176.26 210.35,176.26 209.33,177.28 205.27,177.28 B06.L1 204.25,177.28 203.74,177.28 202.73,176.26 197.65,176.26 197.14,176.77 193.08,176.77 192.57,177.28 B07.L1 191.55,177.28 191.04,176.77 186.98,176.77 186.47,176.26 184.44,176.26 183.42,177.28 179.87,177.28 B08.L1 178.85,177.28 177.84,176.26 168.18,176.26 167.17,177.28 164.12,177.28 B09.L1 159.55,177.79 158.02,179.31 155.48,179.31 154.47,178.3 151.42,178.3 B10.L1 150.4,178.3 149.9,178.8 145.83,178.8 145.32,179.31 142.78,179.31 141.77,178.3 138.72,178.3 B11.L1 137.7,178.3 137.2,178.3 136.18,179.31 131.1,179.31 130.59,178.8 126.53,178.8 126.02,178.3 B12.L1 125,178.3 120.94,178.3 119.92,179.31 111.8,179.31 110.27,177.79 B13.L1 109.26,177.28 108.24,176.26 102.65,176.26 101.13,177.79 B14.L1 | v87.92,26.91 79.28,26.91 78.27,25.9 D15.T2 | v37.63,162.55 33.56,162.55 B19.S1 | v37.63,185.41 38.14,185.92 91.48,185.92 v91.98,186.42
D04MD6L  (via drill 0.61)
  Top 0.254: v25.94,189.98 25.94,188.46 26.45,187.95 B19.H2 | v14.26,192.01 12.74,192.01 12.74,209.28 10.2,211.82 10.2,218.94 12.74,221.48 12.74,224.02 12.23,224.52 12.23,227.57 12.74,228.08 v12.74,231.13 | v63.03,230.62 67.09,230.62 67.09,224.02 71.16,219.95 72.68,219.95 72.68,219.44 v74.71,217.41 | v90.97,211.32 95.54,206.74 v95.54,189.47 | v103.16,188.46 108.24,183.38 108.24,181.34 110.78,178.8 110.78,176.77 112.3,175.25 B13.M1 | v109.76,71.62 111.29,73.14 111.29,74.66 v113.83,77.2 | v118.4,84.32 117.89,84.82 117.89,135.12 123.99,141.21 123.99,167.63 128.05,171.69 128.05,174.23 B12.M1
  Bottom 0.254: B14.M1 100.62,174.23 101.64,173.22 111.29,173.22 112.3,174.23 B13.M1 113.32,174.23 114.34,173.22 127.04,173.22 128.05,174.23 B12.M1 129.07,174.23 130.08,173.22 139.74,173.22 | v25.94,189.98 23.91,192.01 19.85,192.01 18.32,193.54 16.29,193.54 14.77,192.01 v14.26,192.01 | v12.74,231.13 13.75,230.11 15.78,230.11 16.29,230.62 19.34,230.62 19.85,230.11 22.39,230.11 22.9,230.62 26.45,230.62 26.96,230.11 28.48,230.11 28.99,230.62 32.04,230.62 32.55,230.11 62.52,230.11 v63.03,230.62 | v74.71,217.41 80.81,211.32 v90.97,211.32 | v95.54,189.47 96.05,188.96 98.59,188.96 99.1,189.47 102.14,189.47 v103.16,188.46 | v109.76,71.62 89.95,71.62 86.9,68.57 76.74,68.57 75.22,67.04 D16.C1 | v113.83,77.2 117.89,81.27 117.89,84.32 v118.4,84.32 | 139.74,173.22 140.75,174.23 B11.M1 | 139.74,173.22 152.44,173.22 153.45,174.23 B10.M1 154.47,174.23 155.48,173.22 165.14,173.22 | 165.14,173.22 166.15,174.23 B09.M1 | 180.88,173.22 181.9,174.23 B08.M1 | 165.14,173.22 180.88,173.22 | 193.58,173.22 194.6,174.23 B07.M1 | 180.88,173.22 193.58,173.22 | 206.28,173.22 207.3,174.23 B06.M1 | 193.58,173.22 206.28,173.22 | 218.98,173.22 220,174.23 B05.M1 | 206.28,173.22 218.98,173.22 | 235.24,173.22 236.26,174.23 B04.M1 | 218.98,173.22 235.24,173.22 | 247.94,173.22 248.96,174.23 B03.M1 | 235.24,173.22 247.94,173.22 | 260.64,173.22 261.66,174.23 B02.M1 | 247.94,173.22 260.64,173.22 | 260.64,173.22 273.34,173.22 274.36,174.23 B01.M1
D04MD7L  (via drill 0.61)
  Top 0.254: B03.P1 249.97,168.64 254.04,168.64 255.05,169.66 261.66,169.66 261.66,168.64 B02.P1 | B07.P1 195.62,168.64 200.19,168.64 200.19,169.15 200.7,169.66 207.3,169.66 207.3,168.64 B06.P1 | v175.3,169.66 181.9,169.66 181.9,168.64 B08.P1 | v69.12,56.88 69.12,59.42 68.62,59.93 D16.E2 | v111.29,56.38 111.29,62.98 114.84,66.54 114.84,104.64 113.83,105.65 113.83,110.22 114.34,110.73 114.34,164.58 112.81,166.1 112.81,167.63 B13.P1 113.32,168.64 v113.32,170.68 | v23.4,179.82 23.4,183.38 B19.J2 | v29.5,174.23 31.53,172.2 v31.53,156.45 | v51.34,153.91 52.36,152.9 v52.36,149.85 | v71.16,150.36 71.66,149.85 v71.66,147.82 | v96.05,146.8 95.54,147.31 95.54,166.61 v97.06,168.14
  Bottom 0.254: B03.P1 248.96,167.63 245.4,167.63 244.38,166.61 238.8,166.61 237.27,168.14 B04.P1 236.26,167.63 235.75,167.12 231.18,167.12 230.67,166.61 226.6,166.61 225.59,167.63 221.02,167.63 B05.P1 220,168.14 217.46,168.14 215.94,166.61 213.9,166.61 213.4,167.12 208.82,167.12 208.32,167.63 B06.P1 | B02.P1 262.67,168.14 263.69,167.12 267.75,167.12 268.26,166.61 273.34,166.61 274.36,167.63 B01.P1 | 139.74,169.66 130.08,169.66 129.07,168.64 B12.P1 128.05,168.64 126.53,170.17 113.83,170.17 v113.32,170.68 | 139.74,169.66 140.75,168.64 B11.P1 | 152.44,169.66 153.45,168.64 B10.P1 | 139.74,169.66 152.44,169.66 | 152.44,169.66 165.14,169.66 166.15,168.64 B09.P1 167.17,168.64 168.18,169.66 v175.3,169.66 | B08.P1 182.92,167.63 183.93,166.61 190.54,166.61 192.06,168.14 194.6,168.14 B07.P1 | v69.12,56.88 70.65,55.36 98.08,55.36 98.59,55.87 110.78,55.87 v111.29,56.38 | B13.P1 112.3,167.63 110.27,167.63 109.26,166.61 105.7,166.61 105.19,167.12 101.64,167.12 100.62,168.14 B14.P1 99.6,168.14 v97.06,168.14 | v23.4,179.82 21.88,178.3 21.88,176.26 27.47,176.26 v29.5,174.23 | v31.53,156.45 31.53,153.91 36.61,153.91 39.66,150.86 45.25,150.86 48.3,153.91 v51.34,153.91 | v52.36,149.85 52.87,150.36 v71.16,150.36 | v71.66,147.82 72.68,146.8 v96.05,146.8
D04MD8L  (via drill 0.61)
  Top 0.254: v24.93,147.82 24.93,169.66 23.91,170.68 B19.N2 | v11.72,146.29 8.67,143.24 8.67,132.07 7.15,130.54 7.15,96.51 8.16,95.49 8.16,64.5 9.18,63.49 v9.18,44.69 | v33.06,43.17 34.58,44.69 v34.58,50.28
  Bottom 0.254: D01.K1 274.36,48.25 273.34,49.26 268.26,49.26 267.75,48.76 263.69,48.76 262.67,47.74 D02.K1 261.66,48.25 257.08,48.25 256.07,49.26 255.56,49.26 255.05,48.76 250.99,48.76 249.97,47.74 D03.K1 248.96,48.25 244.38,48.25 243.37,49.26 242.86,49.26 242.35,48.76 238.29,48.76 237.27,47.74 D04.K1 236.26,48.25 235.75,48.76 231.18,48.76 230.67,49.26 226.6,49.26 225.59,48.25 221.02,48.25 D05.K1 220,47.74 218.98,48.76 214.92,48.76 214.41,49.26 210.86,49.26 209.84,48.25 208.32,48.25 D06.K1 207.3,47.74 206.28,48.76 202.22,48.76 201.71,49.26 198.16,49.26 197.14,48.25 195.62,48.25 D07.K1 194.6,47.74 191.55,47.74 190.03,49.26 188.5,49.26 188,48.76 183.42,48.76 182.92,48.25 D08.K1 181.9,47.74 179.36,47.74 177.84,49.26 175.8,49.26 175.3,48.76 167.68,48.76 167.17,48.25 D09.K1 166.15,47.74 165.14,48.76 161.58,48.76 161.07,49.26 155.99,49.26 154.98,48.25 154.47,48.25 D10.K1 153.45,47.74 152.44,48.76 148.88,48.76 148.37,49.26 143.29,49.26 142.28,48.25 141.77,48.25 D11.K1 140.75,47.74 137.7,47.74 136.18,49.26 134.15,49.26 133.64,48.76 129.58,48.76 129.07,48.25 D12.K1 128.05,47.74 127.04,48.76 123.48,48.76 122.97,49.26 117.89,49.26 116.37,47.74 113.32,47.74 D13.K1 112.3,48.25 108.75,48.25 107.73,49.26 105.7,49.26 105.19,48.76 101.64,48.76 100.62,47.74 D14.K1 99.6,48.25 96.05,48.25 95.03,49.26 83.35,49.26 80.3,52.31 73.7,52.31 | 73.7,52.31 72.17,50.79 D16.J1 | v24.93,147.82 24.42,148.32 13.75,148.32 v11.72,146.29 | v9.18,44.69 9.18,43.17 v33.06,43.17 | v34.58,50.28 34.58,52.31 73.7,52.31
D04MD9L  (via drill 0.61)
  Top 0.254: v22.9,142.74 25.94,145.78 25.94,148.32 25.44,148.83 25.44,166.61 26.45,167.63 B19.P2 | v10.2,141.21 9.18,140.2 9.18,129.53 7.66,128 7.66,97.02 8.67,96 8.67,65.01 9.69,64 9.69,48.25 12.74,45.2 v12.74,40.63
  Bottom 0.254: 94.52,43.17 95.03,43.68 96.56,43.68 D14.L1 | 94.52,43.17 94.02,42.66 69.63,42.66 68.62,41.64 D16.M2 67.6,41.14 63.03,41.14 58.46,36.56 48.8,36.56 45.76,39.61 13.75,39.61 v12.74,40.63 | 108.75,43.17 109.26,43.68 D13.L1 | 108.75,43.17 94.52,43.17 | v22.9,142.74 21.37,141.21 v10.2,141.21 | 123.99,43.17 125,44.18 D12.L1 | 123.99,43.17 108.75,43.17 | 136.69,43.17 137.7,44.18 D11.L1 | 136.69,43.17 123.99,43.17 | 149.39,43.17 150.4,44.18 D10.L1 | 149.39,43.17 136.69,43.17 | 162.09,43.17 163.1,44.18 D09.L1 | 162.09,43.17 149.39,43.17 | 177.84,43.17 178.85,44.18 D08.L1 | 177.84,43.17 162.09,43.17 | 190.54,43.17 191.55,44.18 D07.L1 | 190.54,43.17 177.84,43.17 | 203.24,43.17 204.25,44.18 D06.L1 | 203.24,43.17 190.54,43.17 | 215.94,43.17 216.95,44.18 D05.L1 | 215.94,43.17 203.24,43.17 | 231.68,43.17 232.7,44.18 D04.L1 | 215.94,43.17 231.68,43.17 | 244.38,43.17 245.4,44.18 D03.L1 | 231.68,43.17 244.38,43.17 | 257.08,43.17 258.1,44.18 D02.L1 | 244.38,43.17 257.08,43.17 | 257.08,43.17 269.78,43.17 270.8,44.18 D01.L1
D04MD10L  (via drill 0.61)
  Top 0.254: v168.69,39.1 167.17,40.63 D09.M1 | v26.96,145.28 26.96,154.93 B19.U2 | v66.58,145.28 66.58,131.56 62.52,127.5 62.52,74.66 62.01,74.16 62.01,54.85 63.03,53.84 v63.03,39.61 | v115.35,42.15 113.32,42.15 113.32,41.64 D13.M1
  Bottom 0.254: 139.74,42.66 130.08,42.66 129.07,41.64 D12.M1 128.05,41.64 127.04,42.66 115.86,42.66 v115.35,42.15 | 139.74,42.66 140.75,41.64 D11.M1 | 152.44,42.66 153.45,41.64 D10.M1 | 152.44,42.66 139.74,42.66 | 152.44,42.66 165.14,42.66 166.15,41.64 D09.M1 | 183.93,39.61 182.92,40.63 D08.M1 | 193.08,39.61 183.93,39.61 | 193.08,39.61 194.6,41.14 D07.M1 | 205.78,39.61 207.3,41.14 D06.M1 | 205.78,39.61 193.08,39.61 | 218.48,39.61 220,41.14 D05.M1 | 218.48,39.61 205.78,39.61 | 235.24,39.61 236.26,40.63 D04.M1 | 218.48,39.61 235.24,39.61 | 247.94,39.61 248.96,40.63 D03.M1 | 235.24,39.61 247.94,39.61 | 260.64,39.61 261.66,40.63 D02.M1 | 247.94,39.61 260.64,39.61 | 260.64,39.61 273.34,39.61 274.36,40.63 D01.M1 | v168.69,39.1 169.2,39.61 183.93,39.61 | 63.54,39.61 63.54,37.58 64.55,36.56 69.12,36.56 69.63,36.06 73.7,36.06 74.2,35.55 D16.P1 | 98.59,39.61 63.54,39.61 | 98.59,39.61 99.6,40.63 D14.M1 | 98.59,39.61 111.29,39.61 112.3,40.63 D13.M1 | v66.58,145.28 v26.96,145.28 | 63.54,39.61 v63.03,39.61
D04MD11L  (via drill 0.61)
  Top 0.254: v67.09,30.98 67.09,27.42 65.57,25.9 D16.T2 | v22.9,145.28 22.9,151.88 B19.V2 | v9.18,145.28 8.16,144.26 8.16,132.58 6.64,131.05 6.64,96 7.66,94.98 7.66,64 8.16,63.49 8.16,44.18 9.69,42.66 v9.69,36.06
  Bottom 0.254: v67.09,30.98 67.6,30.47 86.9,30.47 89.95,33.52 98.59,33.52 | 98.59,33.52 99.6,34.53 D14.P1 | 111.29,33.52 112.3,34.53 D13.P1 | 111.29,33.52 98.59,33.52 | v9.18,145.28 v22.9,145.28 | v9.69,36.06 18.83,26.91 44.23,26.91 44.74,26.4 48.3,26.4 48.8,26.91 56.93,26.91 57.95,25.9 64.55,25.9 D16.T2 | 127.04,33.52 128.05,34.53 D12.P1 | 127.04,33.52 111.29,33.52 | 139.74,33.52 140.75,34.53 D11.P1 | 139.74,33.52 127.04,33.52 | 152.44,33.52 153.45,34.53 D10.P1 | 152.44,33.52 139.74,33.52 | 165.14,33.52 166.15,34.53 D09.P1 | 165.14,33.52 152.44,33.52 | 180.88,33.52 181.9,34.53 D08.P1 | 180.88,33.52 165.14,33.52 | 193.58,33.52 194.6,34.53 D07.P1 | 193.58,33.52 180.88,33.52 | 206.28,33.52 207.3,34.53 D06.P1 | 206.28,33.52 193.58,33.52 | 218.98,33.52 220,34.53 D05.P1 | 218.98,33.52 206.28,33.52 | 235.24,33.52 236.26,34.53 D04.P1 | 235.24,33.52 218.98,33.52 | 247.94,33.52 248.96,34.53 D03.P1 | 235.24,33.52 247.94,33.52 | 260.64,33.52 261.66,34.53 D02.P1 | 247.94,33.52 260.64,33.52 | 260.64,33.52 273.34,33.52 274.36,34.53 D01.P1
GND
  Top 0.635: A13.F1 109.26,260.08 103.67,260.08 A13.F2 | A11.F1 138.72,260.08 143.8,260.08 A10.F2 144.82,260.08 150.4,260.08 A10.F1 | A12.F2 119.42,260.08 125,260.08 A12.F1 | A05.F1 216.95,260.08 211.87,260.08 A05.F2 210.86,260.08 205.27,260.08 A06.F1 | A08.F2 173.77,260.08 178.85,260.08 A08.F1 179.87,260.08 185.46,260.08 A07.F2 186.47,260.08 187.49,260.08 | 187.49,260.08 191.55,260.08 A07.F1 192.57,260.08 198.16,260.08 A06.F2 | A01.F1 270.8,260.08 265.72,260.08 A01.F2 264.7,260.08 259.12,260.08 A02.F1 258.1,260.08 253.02,260.08 A02.F2 252,260.08 246.42,260.08 A03.F1 245.4,260.08 240.32,260.08 A03.F2 239.3,260.08 233.72,260.08 A04.F1 232.7,260.08 227.62,260.08 A04.F2 | 98.59,269.23 99.6,269.23 A14.C1 | 98.59,269.23 94.02,269.23 A14.C2 | A12.C1 129.07,269.23 134.66,269.23 A11.C2 135.67,269.74 140.75,269.74 A11.C1 141.77,269.23 147.36,269.23 A10.C2 148.37,269.74 153.45,269.74 A10.C1 154.47,269.23 160.06,269.23 A09.C2 | A05.C1 220,269.74 214.92,269.74 A05.C2 213.9,269.23 208.32,269.23 A06.C1 207.3,269.74 202.22,269.74 A06.C2 201.2,269.23 195.62,269.23 A07.C1 194.6,269.74 189.52,269.74 A07.C2 188.5,269.23 182.92,269.23 A08.C1 181.9,269.74 176.82,269.74 A08.C2 | GND.1 279.94,269.74 275.37,269.74 A01.C1 274.36,269.23 268.77,269.23 A01.C2 267.75,269.74 262.67,269.74 A02.C1 261.66,269.23 256.07,269.23 A02.C2 255.05,269.74 249.97,269.74 A03.C1 248.96,269.23 243.37,269.23 A03.C2 242.35,269.74 237.27,269.74 A04.C1 236.26,269.23 230.67,269.23 A04.C2 | 98.59,269.23 98.59,262.62 97.06,261.1 A14.F1 | A09.N1 163.1,240.78 157.52,240.78 A09.N2 | A11.N2 A12.N1
  Top 0.635: A10.N1 150.4,240.78 144.82,240.78 A10.N2 | A06.N1 A06.N2 | A08.N1 A08.N2 | 187.49,241.29 A07.N2 | A07.N1 187.49,241.29 | A01.N1 A01.N2 264.7,240.78 259.12,240.78 A02.N1 A02.N2 252,240.78 246.42,240.78 A03.N1 A03.N2 239.3,240.78 233.72,240.78 A04.N1 A04.N2 | A16.A1 74.2,275.83 74.2,270.24 A16.C1 | A18N.C1 46.77,269.74 51.85,269.74 A17N.C2 52.87,269.23 53.88,268.21 53.88,260.08 | A18N.A1 45.76,275.83 45.76,270.24 A18N.C1 | A17N.A1 58.46,275.83 58.46,270.24 A17N.C1 | A19N.A1 33.06,275.83 33.06,270.24 A19N.C1 | A20N.A1 20.36,275.83 20.36,270.24 A20N.C1 | A18N.C1 45.76,269.23 40.17,269.23 A18N.C2 | A20N.U2 14.77,226.05 17.31,226.05 17.31,228.08 A20N.T1 17.31,229.1 17.31,234.18 A20N.R1 | A20N.R2 11.21,235.7 11.21,240.78 A20N.N2 11.21,241.8 11.21,246.88 A20N.L2 11.21,248.4 11.21,253.48 A20N.J2 11.21,254.5 11.21,259.58 A20N.F2 | A19N.U2 27.47,226.05 30.01,226.05 30.01,228.08 A19N.T1 30.01,229.1 30.01,234.18 A19N.R1 | A19N.R2 23.91,235.7 23.91,240.78 A19N.N2 23.91,241.8 23.91,246.88 A19N.L2 23.4,247.89 21.37,249.92 21.37,250.43 A20N.K1 21.37,250.94 21.37,251.45 23.4,253.48 A19N.J2 23.91,254.5 23.91,259.58 A19N.F2 | A16.T1 71.16,229.1 71.16,234.18 A16.R1 71.16,235.7 71.16,240.78 A16.N1 | A16.R2 65.06,235.7 65.06,240.78 A16.N2 65.06,241.8 65.06,246.88 A16.L2 65.06,248.4 65.06,253.48 A16.J2 65.06,254.5 65.06,259.58 A16.F2 | A16.K1 74.2,251.45 73.7,251.96 73.7,255.51 71.66,257.54 71.66,259.58 A16.F1 | A18N.U2 40.17,226.05 42.2,228.08 42.2,228.59 A18N.T1 42.71,229.1 42.71,234.18 A18N.R1 | A18N.R2 36.61,235.7 36.61,240.78 A18N.N2 36.61,241.8 36.61,246.88 A18N.L2 36.1,247.89 36.1,248.4 34.07,250.43 A19N.K1 34.07,250.94 34.07,251.45 36.1,253.48 A18N.J2 36.61,254.5 36.61,259.58 A18N.F2
  Top 0.635: A17N.U2 52.87,226.05 54.9,228.08 54.9,228.59 A17N.T1 55.41,229.1 55.41,234.18 A17N.R1 55.41,235.7 55.41,240.78 A17N.N1 | A17N.R2 49.31,235.7 49.31,240.78 A17N.N2 49.31,241.8 49.31,246.88 A17N.L2 48.8,247.89 48.8,248.4 46.77,250.43 A18N.K1 46.77,250.94 46.77,251.45 48.8,253.48 A17N.J2 49.31,254.5 49.31,259.58 A17N.F2 49.82,260.08 53.88,260.08 | 53.88,260.08 54.9,260.08 A17N.F1 | A09.T1 163.1,228.08 157.52,228.08 A09.T2 | A10.T1 150.4,228.08 144.82,228.08 A10.T2 | 215.94,228.59 A05.T2 | A05.T1 215.94,228.59 | A06.T1 A06.T2 | A08.T1 A08.T2 | A07.T1 A07.T2 | A01.T1 A01.T2 264.7,228.08 259.12,228.08 A02.T1 A02.T2 252,228.08 | A04.T2 A04.T1 233.72,228.08 239.3,228.08 A03.T2 A03.T1 246.42,228.08 252,228.08 | 215.94,228.59 215.94,239.76 216.95,240.78 A05.N1 | 187.49,241.29 187.49,260.08 | B12.N2 119.42,171.18 125,171.18 B12.N1 | 212.89,171.18 216.95,171.18 B05.N1 | 212.89,171.18 211.87,171.18 B05.N2 | B06.N2 199.17,171.18 204.25,171.18 B06.N1 | B07.N1 191.55,171.18 186.47,171.18 B07.N2 185.46,171.18 179.87,171.18 B08.N1 179.36,172.2 180.88,173.72 180.88,189.98 | B01.N1 270.8,171.18 265.72,171.18 B01.N2 264.7,171.18 259.12,171.18 B02.N1 258.1,171.18 253.02,171.18 B02.N2 252,171.18 246.42,171.18 B03.N1 245.4,171.18 240.32,171.18 B03.N2 | B04.N2 227.62,171.18 232.7,171.18 B04.N1 | 212.89,158.48 216.95,158.48 B05.T1 | 212.89,158.48 211.87,158.48 B05.T2 | B06.T1 204.25,158.48 199.17,158.48 B06.T2 198.16,158.48 192.57,158.48 B07.T1 | B08.T1 179.87,158.48 185.46,158.48 B07.T2 | B01.T1 270.8,158.48 265.72,158.48 B01.T2 264.7,158.48 259.12,158.48 B02.T1 258.1,158.48 253.02,158.48 B02.T2 252,158.48 246.42,158.48 B03.T1 245.4,158.48 240.32,158.48 B03.T2
  Top 0.635: B04.T2 227.62,158.48 232.7,158.48 B04.T1 | B11.T2 131.1,158.48 126.02,158.48 B12.T1 | B17.T1 55.41,159.5 55.41,164.58 B17.R1 | 212.89,158.48 212.89,171.18 | B11.F2 B12.F1 | B05.F2 B05.F1 | B06.F2 B06.F1 | B07.F1 B07.F2 185.46,189.98 180.88,189.98 | 180.88,189.98 179.87,189.98 B08.F1 | B01.F1 B01.F2 264.7,189.98 259.12,189.98 B02.F1 B02.F2 252,189.98 246.42,189.98 B03.F1 B03.F2 | B04.F2 B04.F1 | B01.C1 274.36,199.63 268.77,199.63 B01.C2 267.75,199.63 262.67,199.63 B02.C1 261.66,199.63 256.07,199.63 B02.C2 255.05,199.63 250.99,199.63 | 250.99,199.63 249.97,199.63 B03.C1 248.96,199.63 243.37,199.63 B03.C2 | B04.C2 230.67,199.63 236.26,199.63 B04.C1 | 149.39,199.63 153.45,199.63 B10.C1 | 149.39,199.63 148.37,199.63 B10.C2 | B12.C2 122.97,199.63 128.05,199.63 B12.C1 129.07,199.63 134.66,199.63 B11.C2 | B05.C2 214.92,199.63 220,199.63 B05.C1 | B08.C2 176.82,199.63 181.9,199.63 B08.C1 | B06.C2 201.2,199.63 195.62,199.63 B07.C1 | 149.39,199.63 149.39,192.01 150.4,191 B10.F1 | D14.N1 D13.N2 102.65,37.58 101.64,36.56 101.64,25.39 | D09.N2 D10.N1 | D12.N1 D11.N2 132.12,37.58 137.7,37.58 D11.N1 | D08.N2 D08.N1 179.87,37.58 185.46,37.58 D07.N2 D07.N1 | D06.N2 198.16,37.58 192.57,37.58 D07.N1 | D06.N1 205.27,37.58 210.86,37.58 D05.N2 D05.N1 217.97,37.58 226.6,37.58 D04.N2 D04.N1 233.72,37.58 239.3,37.58 D03.N2 | D01.N1 D01.N2 264.7,37.58 259.12,37.58 D02.N1 D02.N2 252,37.58 246.42,37.58 D03.N1 | D08.T2 D08.T1 179.87,24.88 185.46,24.88 D07.T2 | D07.T1 192.57,24.88 198.16,24.88 D06.T2 D06.T1 205.27,24.88 210.86,24.88 D05.T2 D05.T1 217.97,24.88 226.6,24.88 D04.T2 | D01.T1 D01.T2 264.7,24.88 259.12,24.88 D02.T1 D02.T2 252,24.88 246.42,24.88 D03.T1 D03.T2 239.3,24.88 233.72,24.88 D04.T1
  Top 0.635: 101.64,25.39 D14.T1 | 101.64,25.39 D13.T2 | D11.T1 D10.T2 | D12.F2 119.42,56.88 125,56.88 D12.F1 126.02,56.88 131.1,56.88 D11.F2 | D11.F1 137.7,56.88 132.12,56.88 D11.F2 | D05.F1 216.95,56.88 211.87,56.88 D05.F2 210.86,56.88 205.27,56.88 D06.F1 204.25,56.88 199.17,56.88 D06.F2 198.16,56.88 192.57,56.88 D07.F1 191.55,56.88 190.54,56.88 | 190.54,56.88 186.47,56.88 D07.F2 185.46,56.88 179.87,56.88 D08.F1 | D01.F2 265.72,56.88 270.8,56.88 D01.F1 | D02.F1 258.1,56.88 253.02,56.88 D02.F2 252,56.88 246.42,56.88 D03.F1 245.4,56.88 240.32,56.88 D03.F2 239.3,56.88 233.72,56.88 D04.F1 232.7,56.88 227.62,56.88 D04.F2 | D05.C1 220,66.54 214.92,66.54 D05.C2 213.9,66.03 208.32,66.03 D06.C1 207.3,66.54 202.22,66.54 D06.C2 201.2,66.03 195.62,66.03 D07.C1 194.6,66.54 189.52,66.54 D07.C2 188.5,66.03 182.92,66.03 D08.C1 181.9,66.54 176.82,66.54 D08.C2 | D02.C1 262.67,66.54 267.75,66.54 D01.C2 | D04.C2 230.67,66.03 236.26,66.03 D04.C1 237.27,66.54 242.35,66.54 D03.C2 243.37,66.03 248.96,66.03 D03.C1 249.97,66.54 255.05,66.54 D02.C2 256.07,66.03 261.66,66.03 D02.C1 | D13.C1 112.3,66.03 106.72,66.03 D13.C2 | D09.C2 161.07,66.54 166.15,66.54 D09.C1 | D10.C2 148.37,66.54 153.45,66.54 D10.C1 | D12.C2 122.97,66.54 128.05,66.54 D12.C1 129.07,66.03 130.08,66.03 | D11.C1 140.75,66.54 135.67,66.54 D11.C2 134.66,66.03 130.08,66.03 | 130.08,66.03 130.08,59.42 131.61,57.9 D11.F2 | 190.54,56.88 190.54,39.61 191.55,38.6 D07.N1 | C12.N2 119.42,107.68 125,107.68 C12.N1 126.02,108.19 131.1,108.19 C11.N2 | 212.89,107.68 216.95,107.68 C05.N1 | 212.89,107.68 211.87,107.68 C05.N2 210.86,107.68 205.27,107.68 C06.N1 204.25,107.68 199.17,107.68 C06.N2 198.16,107.68 192.57,107.68 C07.N1 191.55,107.68 186.47,107.68 C07.N2 185.46,107.68 179.87,107.68 C08.N1 179.36,108.7 180.88,110.22 180.88,126.48
  Top 0.635: C01.N1 270.8,107.68 265.72,107.68 C01.N2 264.7,107.68 259.12,107.68 C02.N1 258.1,107.68 253.02,107.68 C02.N2 252,107.68 246.42,107.68 C03.N1 245.4,107.68 240.32,107.68 C03.N2 239.3,107.68 233.72,107.68 C04.N1 232.7,107.68 227.62,107.68 C04.N2 | C09.T1 163.1,94.98 157.52,94.98 C09.T2 | C11.T1 137.7,94.98 132.12,94.98 C11.T2 | 212.89,94.98 216.95,94.98 C05.T1 | 212.89,94.98 211.87,94.98 C05.T2 210.86,94.98 205.27,94.98 C06.T1 204.25,94.98 199.17,94.98 C06.T2 198.16,94.98 192.57,94.98 C07.T1 191.55,94.98 186.47,94.98 C07.T2 185.46,94.98 179.87,94.98 C08.T1 | C01.T1 270.8,94.98 265.72,94.98 C01.T2 264.7,94.98 263.69,94.98 | C04.T1 233.72,94.98 239.3,94.98 C03.T2 240.32,94.98 245.4,94.98 C03.T1 246.42,94.98 252,94.98 C02.T2 253.02,94.98 258.1,94.98 C02.T1 259.12,94.98 263.69,94.98 | 212.89,94.98 212.89,107.68 | C13.F2 C14.F1 | C11.F2 C12.F1 | 180.88,126.48 185.46,126.48 C07.F2 C07.F1 192.57,126.48 198.16,126.48 C06.F2 C06.F1 205.27,126.48 210.86,126.48 C05.F2 C05.F1 216.95,127.5 215.94,128.51 215.94,136.13 | 180.88,126.48 179.87,126.48 C08.F1 | C01.F1 C01.F2 264.7,126.48 259.12,126.48 C02.F1 C02.F2 252,126.48 246.42,126.48 C03.F1 C03.F2 239.3,126.48 233.72,126.48 C04.F1 C04.F2 | 42.2,154.93 42.2,157.98 B18.T1 | 42.2,154.93 42.2,152.9 B18.V1 42.2,151.88 42.2,141.72 40.17,139.69 40.17,137.15 C18.C2 | 42.2,154.93 45.25,154.93 B18.U1 | B20.T1 16.8,157.98 16.8,152.9 B20.V1 | B19.U1 32.55,154.93 30.52,152.9 B19.V1 29.5,152.9 29.5,157.98 B19.T1 | C17.C2 51.85,136.13 51.85,130.54 C17.E2 52.87,129.53 52.87,125.97 55.41,123.43 55.41,121.4 C17.J1 55.41,119.88 55.41,117.34 53.88,115.81 53.88,112.76
  Top 0.635: 53.88,112.76 52.87,111.75 C17.M2 | C17.T1 55.92,96 55.92,98.03 57.44,99.56 57.44,103.11 58.46,104.13 C17.P1 58.46,105.14 58.46,108.19 53.88,112.76 | 139.74,136.64 140.75,136.64 C11.C1 | 139.74,136.64 135.67,136.64 C11.C2 134.66,136.13 129.07,136.13 C12.C1 | 215.94,136.13 220,136.13 C05.C1 | 215.94,136.13 214.92,136.13 C05.C2 213.9,136.13 208.32,136.13 C06.C1 207.3,136.13 202.22,136.13 C06.C2 201.2,136.13 195.62,136.13 C07.C1 194.6,136.13 189.52,136.13 C07.C2 188.5,136.13 182.92,136.13 C08.C1 181.9,136.13 176.82,136.13 C08.C2 | C01.C1 274.36,136.13 268.77,136.13 C01.C2 267.75,136.13 262.67,136.13 C02.C1 261.66,136.13 256.07,136.13 C02.C2 255.05,136.13 249.97,136.13 C03.C1 248.96,136.13 243.37,136.13 C03.C2 242.35,136.13 237.27,136.13 C04.C1 236.26,136.13 230.67,136.13 C04.C2 | 263.69,94.98 263.69,68.06 262.67,67.04 D02.C1 | 139.74,136.64 139.74,156.45 138.21,157.98 B11.T1 | 252,228.08 250.99,227.06 250.99,199.63